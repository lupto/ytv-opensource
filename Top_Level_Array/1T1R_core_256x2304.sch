v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {devices/iopin.sym} 0 -200 0 1 {name=p1 lab=BL[2303:0]}
C {devices/iopin.sym} 0 200 2 0 {name=p2 lab=SL[2303:0]}
C {devices/ipin.sym} -180 0 0 0 {name=p3 lab=WL[255:0]}
C {devices/ipin.sym} 180 0 0 1 {name=p4 lab=AVSS}
C {Top_Level_Array/1T1R_580nm_width_256x32.sym} 0 0 0 0 {name=x1[0:7]}
C {devices/lab_pin.sym} 0 -100 3 1 {name=p5 sig_type=std_logic lab=BL[255:0]}
C {devices/noconn.sym} 50 -210 1 0 {name=l1}
C {devices/noconn.sym} 50 210 3 0 {name=l2}
C {devices/lab_pin.sym} 0 100 1 1 {name=p6 sig_type=std_logic lab=SL[255:0]}
C {devices/lab_pin.sym} 50 -210 1 1 {name=p7 sig_type=std_logic lab=BL[2303:256]}
C {devices/lab_pin.sym} 50 210 3 1 {name=p8 sig_type=std_logic lab=SL[2303:256]}
