v {xschem version=3.1.0 file_version=1.2
}
G {}
K {}
V {}
S {}
E {}
C {Top_Level_Array/1T1R_580nm_width_32x32.sym} 0 0 0 0 {name=x1[0:7]}
C {devices/iopin.sym} 0 -100 3 0 {name=p1 lab=BL[0:31]}
C {devices/iopin.sym} 0 100 1 0 {name=p2 lab=SL[0:31]}
C {devices/ipin.sym} -160 0 0 0 {name=p3 lab=WL[0:255]}
C {devices/ipin.sym} 170 0 0 1 {name=p4 lab=AVSS}
