** sch_path: WL_Interface/WL_interface.sch
**.subckt WL_interface AVSS VSS VDD AVDD
*+ ROW_ADDR[7],ROW_ADDR[6],ROW_ADDR[5],ROW_ADDR[4],ROW_ADDR[3],ROW_ADDR[2],ROW_ADDR[1],ROW_ADDR[0] SET_FORM SET_RST WE ARRAY_EN VWL_SET VWL_RESET VWL_READ VWL_FORM
*+ VWL[255],VWL[254],VWL[253],VWL[252],VWL[251],VWL[250],VWL[249],VWL[248],VWL[247],VWL[246],VWL[245],VWL[244],VWL[243],VWL[242],VWL[241],VWL[240],VWL[239],VWL[238],VWL[237],VWL[236],VWL[235],VWL[234],VWL[233],VWL[232],VWL[231],VWL[230],VWL[229],VWL[228],VWL[227],VWL[226],VWL[225],VWL[224],VWL[223],VWL[222],VWL[221],VWL[220],VWL[219],VWL[218],VWL[217],VWL[216],VWL[215],VWL[214],VWL[213],VWL[212],VWL[211],VWL[210],VWL[209],VWL[208],VWL[207],VWL[206],VWL[205],VWL[204],VWL[203],VWL[202],VWL[201],VWL[200],VWL[199],VWL[198],VWL[197],VWL[196],VWL[195],VWL[194],VWL[193],VWL[192],VWL[191],VWL[190],VWL[189],VWL[188],VWL[187],VWL[186],VWL[185],VWL[184],VWL[183],VWL[182],VWL[181],VWL[180],VWL[179],VWL[178],VWL[177],VWL[176],VWL[175],VWL[174],VWL[173],VWL[172],VWL[171],VWL[170],VWL[169],VWL[168],VWL[167],VWL[166],VWL[165],VWL[164],VWL[163],VWL[162],VWL[161],VWL[160],VWL[159],VWL[158],VWL[157],VWL[156],VWL[155],VWL[154],VWL[153],VWL[152],VWL[151],VWL[150],VWL[149],VWL[148],VWL[147],VWL[146],VWL[145],VWL[144],VWL[143],VWL[142],VWL[141],VWL[140],VWL[139],VWL[138],VWL[137],VWL[136],VWL[135],VWL[134],VWL[133],VWL[132],VWL[131],VWL[130],VWL[129],VWL[128],VWL[127],VWL[126],VWL[125],VWL[124],VWL[123],VWL[122],VWL[121],VWL[120],VWL[119],VWL[118],VWL[117],VWL[116],VWL[115],VWL[114],VWL[113],VWL[112],VWL[111],VWL[110],VWL[109],VWL[108],VWL[107],VWL[106],VWL[105],VWL[104],VWL[103],VWL[102],VWL[101],VWL[100],VWL[99],VWL[98],VWL[97],VWL[96],VWL[95],VWL[94],VWL[93],VWL[92],VWL[91],VWL[90],VWL[89],VWL[88],VWL[87],VWL[86],VWL[85],VWL[84],VWL[83],VWL[82],VWL[81],VWL[80],VWL[79],VWL[78],VWL[77],VWL[76],VWL[75],VWL[74],VWL[73],VWL[72],VWL[71],VWL[70],VWL[69],VWL[68],VWL[67],VWL[66],VWL[65],VWL[64],VWL[63],VWL[62],VWL[61],VWL[60],VWL[59],VWL[58],VWL[57],VWL[56],VWL[55],VWL[54],VWL[53],VWL[52],VWL[51],VWL[50],VWL[49],VWL[48],VWL[47],VWL[46],VWL[45],VWL[44],VWL[43],VWL[42],VWL[41],VWL[40],VWL[39],VWL[38],VWL[37],VWL[36],VWL[35],VWL[34],VWL[33],VWL[32],VWL[31],VWL[30],VWL[29],VWL[28],VWL[27],VWL[26],VWL[25],VWL[24],VWL[23],VWL[22],VWL[21],VWL[20],VWL[19],VWL[18],VWL[17],VWL[16],VWL[15],VWL[14],VWL[13],VWL[12],VWL[11],VWL[10],VWL[9],VWL[8],VWL[7],VWL[6],VWL[5],VWL[4],VWL[3],VWL[2],VWL[1],VWL[0] ROW_SELECT[0] SET_FORM_BUF SET_RST_BUF WE_BUF
*+ SLICE_ARRAY_EN_BUF[15],SLICE_ARRAY_EN_BUF[14],SLICE_ARRAY_EN_BUF[13],SLICE_ARRAY_EN_BUF[12],SLICE_ARRAY_EN_BUF[11],SLICE_ARRAY_EN_BUF[10],SLICE_ARRAY_EN_BUF[9],SLICE_ARRAY_EN_BUF[8],SLICE_ARRAY_EN_BUF[7],SLICE_ARRAY_EN_BUF[6],SLICE_ARRAY_EN_BUF[5],SLICE_ARRAY_EN_BUF[4],SLICE_ARRAY_EN_BUF[3],SLICE_ARRAY_EN_BUF[2],SLICE_ARRAY_EN_BUF[1],SLICE_ARRAY_EN_BUF[0]
*+ SLICE_SET_FORM_BUF[15],SLICE_SET_FORM_BUF[14],SLICE_SET_FORM_BUF[13],SLICE_SET_FORM_BUF[12],SLICE_SET_FORM_BUF[11],SLICE_SET_FORM_BUF[10],SLICE_SET_FORM_BUF[9],SLICE_SET_FORM_BUF[8],SLICE_SET_FORM_BUF[7],SLICE_SET_FORM_BUF[6],SLICE_SET_FORM_BUF[5],SLICE_SET_FORM_BUF[4],SLICE_SET_FORM_BUF[3],SLICE_SET_FORM_BUF[2],SLICE_SET_FORM_BUF[1],SLICE_SET_FORM_BUF[0]
*+ SLICE_SET_RST_BUF[15],SLICE_SET_RST_BUF[14],SLICE_SET_RST_BUF[13],SLICE_SET_RST_BUF[12],SLICE_SET_RST_BUF[11],SLICE_SET_RST_BUF[10],SLICE_SET_RST_BUF[9],SLICE_SET_RST_BUF[8],SLICE_SET_RST_BUF[7],SLICE_SET_RST_BUF[6],SLICE_SET_RST_BUF[5],SLICE_SET_RST_BUF[4],SLICE_SET_RST_BUF[3],SLICE_SET_RST_BUF[2],SLICE_SET_RST_BUF[1],SLICE_SET_RST_BUF[0]
*+ SLICE_WE_BUF[15],SLICE_WE_BUF[14],SLICE_WE_BUF[13],SLICE_WE_BUF[12],SLICE_WE_BUF[11],SLICE_WE_BUF[10],SLICE_WE_BUF[9],SLICE_WE_BUF[8],SLICE_WE_BUF[7],SLICE_WE_BUF[6],SLICE_WE_BUF[5],SLICE_WE_BUF[4],SLICE_WE_BUF[3],SLICE_WE_BUF[2],SLICE_WE_BUF[1],SLICE_WE_BUF[0] EN_BUF ROW_SELECT[255]
*.ipin AVSS
*.ipin VSS
*.ipin VDD
*.ipin AVDD
*.ipin
*+ ROW_ADDR[7],ROW_ADDR[6],ROW_ADDR[5],ROW_ADDR[4],ROW_ADDR[3],ROW_ADDR[2],ROW_ADDR[1],ROW_ADDR[0]
*.ipin SET_FORM
*.ipin SET_RST
*.ipin WE
*.ipin ARRAY_EN
*.iopin VWL_SET
*.iopin VWL_RESET
*.iopin VWL_READ
*.iopin VWL_FORM
*.iopin
*+ VWL[255],VWL[254],VWL[253],VWL[252],VWL[251],VWL[250],VWL[249],VWL[248],VWL[247],VWL[246],VWL[245],VWL[244],VWL[243],VWL[242],VWL[241],VWL[240],VWL[239],VWL[238],VWL[237],VWL[236],VWL[235],VWL[234],VWL[233],VWL[232],VWL[231],VWL[230],VWL[229],VWL[228],VWL[227],VWL[226],VWL[225],VWL[224],VWL[223],VWL[222],VWL[221],VWL[220],VWL[219],VWL[218],VWL[217],VWL[216],VWL[215],VWL[214],VWL[213],VWL[212],VWL[211],VWL[210],VWL[209],VWL[208],VWL[207],VWL[206],VWL[205],VWL[204],VWL[203],VWL[202],VWL[201],VWL[200],VWL[199],VWL[198],VWL[197],VWL[196],VWL[195],VWL[194],VWL[193],VWL[192],VWL[191],VWL[190],VWL[189],VWL[188],VWL[187],VWL[186],VWL[185],VWL[184],VWL[183],VWL[182],VWL[181],VWL[180],VWL[179],VWL[178],VWL[177],VWL[176],VWL[175],VWL[174],VWL[173],VWL[172],VWL[171],VWL[170],VWL[169],VWL[168],VWL[167],VWL[166],VWL[165],VWL[164],VWL[163],VWL[162],VWL[161],VWL[160],VWL[159],VWL[158],VWL[157],VWL[156],VWL[155],VWL[154],VWL[153],VWL[152],VWL[151],VWL[150],VWL[149],VWL[148],VWL[147],VWL[146],VWL[145],VWL[144],VWL[143],VWL[142],VWL[141],VWL[140],VWL[139],VWL[138],VWL[137],VWL[136],VWL[135],VWL[134],VWL[133],VWL[132],VWL[131],VWL[130],VWL[129],VWL[128],VWL[127],VWL[126],VWL[125],VWL[124],VWL[123],VWL[122],VWL[121],VWL[120],VWL[119],VWL[118],VWL[117],VWL[116],VWL[115],VWL[114],VWL[113],VWL[112],VWL[111],VWL[110],VWL[109],VWL[108],VWL[107],VWL[106],VWL[105],VWL[104],VWL[103],VWL[102],VWL[101],VWL[100],VWL[99],VWL[98],VWL[97],VWL[96],VWL[95],VWL[94],VWL[93],VWL[92],VWL[91],VWL[90],VWL[89],VWL[88],VWL[87],VWL[86],VWL[85],VWL[84],VWL[83],VWL[82],VWL[81],VWL[80],VWL[79],VWL[78],VWL[77],VWL[76],VWL[75],VWL[74],VWL[73],VWL[72],VWL[71],VWL[70],VWL[69],VWL[68],VWL[67],VWL[66],VWL[65],VWL[64],VWL[63],VWL[62],VWL[61],VWL[60],VWL[59],VWL[58],VWL[57],VWL[56],VWL[55],VWL[54],VWL[53],VWL[52],VWL[51],VWL[50],VWL[49],VWL[48],VWL[47],VWL[46],VWL[45],VWL[44],VWL[43],VWL[42],VWL[41],VWL[40],VWL[39],VWL[38],VWL[37],VWL[36],VWL[35],VWL[34],VWL[33],VWL[32],VWL[31],VWL[30],VWL[29],VWL[28],VWL[27],VWL[26],VWL[25],VWL[24],VWL[23],VWL[22],VWL[21],VWL[20],VWL[19],VWL[18],VWL[17],VWL[16],VWL[15],VWL[14],VWL[13],VWL[12],VWL[11],VWL[10],VWL[9],VWL[8],VWL[7],VWL[6],VWL[5],VWL[4],VWL[3],VWL[2],VWL[1],VWL[0]
*.opin ROW_SELECT[0]
*.opin SET_FORM_BUF
*.opin SET_RST_BUF
*.opin WE_BUF
*.opin
*+ SLICE_ARRAY_EN_BUF[15],SLICE_ARRAY_EN_BUF[14],SLICE_ARRAY_EN_BUF[13],SLICE_ARRAY_EN_BUF[12],SLICE_ARRAY_EN_BUF[11],SLICE_ARRAY_EN_BUF[10],SLICE_ARRAY_EN_BUF[9],SLICE_ARRAY_EN_BUF[8],SLICE_ARRAY_EN_BUF[7],SLICE_ARRAY_EN_BUF[6],SLICE_ARRAY_EN_BUF[5],SLICE_ARRAY_EN_BUF[4],SLICE_ARRAY_EN_BUF[3],SLICE_ARRAY_EN_BUF[2],SLICE_ARRAY_EN_BUF[1],SLICE_ARRAY_EN_BUF[0]
*.opin
*+ SLICE_SET_FORM_BUF[15],SLICE_SET_FORM_BUF[14],SLICE_SET_FORM_BUF[13],SLICE_SET_FORM_BUF[12],SLICE_SET_FORM_BUF[11],SLICE_SET_FORM_BUF[10],SLICE_SET_FORM_BUF[9],SLICE_SET_FORM_BUF[8],SLICE_SET_FORM_BUF[7],SLICE_SET_FORM_BUF[6],SLICE_SET_FORM_BUF[5],SLICE_SET_FORM_BUF[4],SLICE_SET_FORM_BUF[3],SLICE_SET_FORM_BUF[2],SLICE_SET_FORM_BUF[1],SLICE_SET_FORM_BUF[0]
*.opin
*+ SLICE_SET_RST_BUF[15],SLICE_SET_RST_BUF[14],SLICE_SET_RST_BUF[13],SLICE_SET_RST_BUF[12],SLICE_SET_RST_BUF[11],SLICE_SET_RST_BUF[10],SLICE_SET_RST_BUF[9],SLICE_SET_RST_BUF[8],SLICE_SET_RST_BUF[7],SLICE_SET_RST_BUF[6],SLICE_SET_RST_BUF[5],SLICE_SET_RST_BUF[4],SLICE_SET_RST_BUF[3],SLICE_SET_RST_BUF[2],SLICE_SET_RST_BUF[1],SLICE_SET_RST_BUF[0]
*.opin
*+ SLICE_WE_BUF[15],SLICE_WE_BUF[14],SLICE_WE_BUF[13],SLICE_WE_BUF[12],SLICE_WE_BUF[11],SLICE_WE_BUF[10],SLICE_WE_BUF[9],SLICE_WE_BUF[8],SLICE_WE_BUF[7],SLICE_WE_BUF[6],SLICE_WE_BUF[5],SLICE_WE_BUF[4],SLICE_WE_BUF[3],SLICE_WE_BUF[2],SLICE_WE_BUF[1],SLICE_WE_BUF[0]
*.opin EN_BUF
*.opin ROW_SELECT[255]
x1 ARRAY_EN VSS VSS VDD VDD EN_BUF sky130_fd_sc_hd__bufbuf_8
x1[7] EN_BUF ROW_ADDR[7] VSS VSS VDD VDD A[7] sky130_fd_sc_hd__and2_0
x1[6] EN_BUF ROW_ADDR[6] VSS VSS VDD VDD A[6] sky130_fd_sc_hd__and2_0
x1[5] EN_BUF ROW_ADDR[5] VSS VSS VDD VDD A[5] sky130_fd_sc_hd__and2_0
x1[4] EN_BUF ROW_ADDR[4] VSS VSS VDD VDD A[4] sky130_fd_sc_hd__and2_0
x1[3] EN_BUF ROW_ADDR[3] VSS VSS VDD VDD A[3] sky130_fd_sc_hd__and2_0
x1[2] EN_BUF ROW_ADDR[2] VSS VSS VDD VDD A[2] sky130_fd_sc_hd__and2_0
x1[1] EN_BUF ROW_ADDR[1] VSS VSS VDD VDD A[1] sky130_fd_sc_hd__and2_0
x1[0] EN_BUF ROW_ADDR[0] VSS VSS VDD VDD A[0] sky130_fd_sc_hd__and2_0
x2[7] A[7] VSS VSS VDD VDD A_BUF[7] sky130_fd_sc_hd__bufbuf_8
x2[6] A[6] VSS VSS VDD VDD A_BUF[6] sky130_fd_sc_hd__bufbuf_8
x2[5] A[5] VSS VSS VDD VDD A_BUF[5] sky130_fd_sc_hd__bufbuf_8
x2[4] A[4] VSS VSS VDD VDD A_BUF[4] sky130_fd_sc_hd__bufbuf_8
x2[3] A[3] VSS VSS VDD VDD A_BUF[3] sky130_fd_sc_hd__bufbuf_8
x2[2] A[2] VSS VSS VDD VDD A_BUF[2] sky130_fd_sc_hd__bufbuf_8
x2[1] A[1] VSS VSS VDD VDD A_BUF[1] sky130_fd_sc_hd__bufbuf_8
x2[0] A[0] VSS VSS VDD VDD A_BUF[0] sky130_fd_sc_hd__bufbuf_8
x3 SET_FORM VSS VSS VDD VDD SET_FORM_BUF sky130_fd_sc_hd__buf_4
x5[15] EN_BUF VWL_SET ROW_SELECT[255] ROW_SELECT[254] ROW_SELECT[253] ROW_SELECT[252]
+ ROW_SELECT[251] ROW_SELECT[250] ROW_SELECT[249] ROW_SELECT[248] ROW_SELECT[247] ROW_SELECT[246] ROW_SELECT[245]
+ ROW_SELECT[244] ROW_SELECT[243] ROW_SELECT[242] ROW_SELECT[241] ROW_SELECT[240] VWL_RESET AVSS SET_FORM_BUF VSS
+ VWL_READ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[255] VWL[254] VWL[253] VWL[252] VWL[251] VWL[250] VWL[249]
+ VWL[248] VWL[247] VWL[246] VWL[245] VWL[244] VWL[243] VWL[242] VWL[241] VWL[240] AVDD SLICE_ARRAY_EN_BUF[15]
+ SLICE_SET_FORM_BUF[15] SLICE_SET_RST_BUF[15] SLICE_WE_BUF[15] WL_slice
x5[14] EN_BUF VWL_SET ROW_SELECT[239] ROW_SELECT[238] ROW_SELECT[237] ROW_SELECT[236]
+ ROW_SELECT[235] ROW_SELECT[234] ROW_SELECT[233] ROW_SELECT[232] ROW_SELECT[231] ROW_SELECT[230] ROW_SELECT[229]
+ ROW_SELECT[228] ROW_SELECT[227] ROW_SELECT[226] ROW_SELECT[225] ROW_SELECT[224] VWL_RESET AVSS SET_FORM_BUF VSS
+ VWL_READ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[239] VWL[238] VWL[237] VWL[236] VWL[235] VWL[234] VWL[233]
+ VWL[232] VWL[231] VWL[230] VWL[229] VWL[228] VWL[227] VWL[226] VWL[225] VWL[224] AVDD SLICE_ARRAY_EN_BUF[14]
+ SLICE_SET_FORM_BUF[14] SLICE_SET_RST_BUF[14] SLICE_WE_BUF[14] WL_slice
x5[13] EN_BUF VWL_SET ROW_SELECT[223] ROW_SELECT[222] ROW_SELECT[221] ROW_SELECT[220]
+ ROW_SELECT[219] ROW_SELECT[218] ROW_SELECT[217] ROW_SELECT[216] ROW_SELECT[215] ROW_SELECT[214] ROW_SELECT[213]
+ ROW_SELECT[212] ROW_SELECT[211] ROW_SELECT[210] ROW_SELECT[209] ROW_SELECT[208] VWL_RESET AVSS SET_FORM_BUF VSS
+ VWL_READ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[223] VWL[222] VWL[221] VWL[220] VWL[219] VWL[218] VWL[217]
+ VWL[216] VWL[215] VWL[214] VWL[213] VWL[212] VWL[211] VWL[210] VWL[209] VWL[208] AVDD SLICE_ARRAY_EN_BUF[13]
+ SLICE_SET_FORM_BUF[13] SLICE_SET_RST_BUF[13] SLICE_WE_BUF[13] WL_slice
x5[12] EN_BUF VWL_SET ROW_SELECT[207] ROW_SELECT[206] ROW_SELECT[205] ROW_SELECT[204]
+ ROW_SELECT[203] ROW_SELECT[202] ROW_SELECT[201] ROW_SELECT[200] ROW_SELECT[199] ROW_SELECT[198] ROW_SELECT[197]
+ ROW_SELECT[196] ROW_SELECT[195] ROW_SELECT[194] ROW_SELECT[193] ROW_SELECT[192] VWL_RESET AVSS SET_FORM_BUF VSS
+ VWL_READ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[207] VWL[206] VWL[205] VWL[204] VWL[203] VWL[202] VWL[201]
+ VWL[200] VWL[199] VWL[198] VWL[197] VWL[196] VWL[195] VWL[194] VWL[193] VWL[192] AVDD SLICE_ARRAY_EN_BUF[12]
+ SLICE_SET_FORM_BUF[12] SLICE_SET_RST_BUF[12] SLICE_WE_BUF[12] WL_slice
x5[11] EN_BUF VWL_SET ROW_SELECT[191] ROW_SELECT[190] ROW_SELECT[189] ROW_SELECT[188]
+ ROW_SELECT[187] ROW_SELECT[186] ROW_SELECT[185] ROW_SELECT[184] ROW_SELECT[183] ROW_SELECT[182] ROW_SELECT[181]
+ ROW_SELECT[180] ROW_SELECT[179] ROW_SELECT[178] ROW_SELECT[177] ROW_SELECT[176] VWL_RESET AVSS SET_FORM_BUF VSS
+ VWL_READ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[191] VWL[190] VWL[189] VWL[188] VWL[187] VWL[186] VWL[185]
+ VWL[184] VWL[183] VWL[182] VWL[181] VWL[180] VWL[179] VWL[178] VWL[177] VWL[176] AVDD SLICE_ARRAY_EN_BUF[11]
+ SLICE_SET_FORM_BUF[11] SLICE_SET_RST_BUF[11] SLICE_WE_BUF[11] WL_slice
x5[10] EN_BUF VWL_SET ROW_SELECT[175] ROW_SELECT[174] ROW_SELECT[173] ROW_SELECT[172]
+ ROW_SELECT[171] ROW_SELECT[170] ROW_SELECT[169] ROW_SELECT[168] ROW_SELECT[167] ROW_SELECT[166] ROW_SELECT[165]
+ ROW_SELECT[164] ROW_SELECT[163] ROW_SELECT[162] ROW_SELECT[161] ROW_SELECT[160] VWL_RESET AVSS SET_FORM_BUF VSS
+ VWL_READ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[175] VWL[174] VWL[173] VWL[172] VWL[171] VWL[170] VWL[169]
+ VWL[168] VWL[167] VWL[166] VWL[165] VWL[164] VWL[163] VWL[162] VWL[161] VWL[160] AVDD SLICE_ARRAY_EN_BUF[10]
+ SLICE_SET_FORM_BUF[10] SLICE_SET_RST_BUF[10] SLICE_WE_BUF[10] WL_slice
x5[9] EN_BUF VWL_SET ROW_SELECT[159] ROW_SELECT[158] ROW_SELECT[157] ROW_SELECT[156] ROW_SELECT[155]
+ ROW_SELECT[154] ROW_SELECT[153] ROW_SELECT[152] ROW_SELECT[151] ROW_SELECT[150] ROW_SELECT[149] ROW_SELECT[148]
+ ROW_SELECT[147] ROW_SELECT[146] ROW_SELECT[145] ROW_SELECT[144] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ
+ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[159] VWL[158] VWL[157] VWL[156] VWL[155] VWL[154] VWL[153] VWL[152]
+ VWL[151] VWL[150] VWL[149] VWL[148] VWL[147] VWL[146] VWL[145] VWL[144] AVDD SLICE_ARRAY_EN_BUF[9]
+ SLICE_SET_FORM_BUF[9] SLICE_SET_RST_BUF[9] SLICE_WE_BUF[9] WL_slice
x5[8] EN_BUF VWL_SET ROW_SELECT[143] ROW_SELECT[142] ROW_SELECT[141] ROW_SELECT[140] ROW_SELECT[139]
+ ROW_SELECT[138] ROW_SELECT[137] ROW_SELECT[136] ROW_SELECT[135] ROW_SELECT[134] ROW_SELECT[133] ROW_SELECT[132]
+ ROW_SELECT[131] ROW_SELECT[130] ROW_SELECT[129] ROW_SELECT[128] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ
+ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[143] VWL[142] VWL[141] VWL[140] VWL[139] VWL[138] VWL[137] VWL[136]
+ VWL[135] VWL[134] VWL[133] VWL[132] VWL[131] VWL[130] VWL[129] VWL[128] AVDD SLICE_ARRAY_EN_BUF[8]
+ SLICE_SET_FORM_BUF[8] SLICE_SET_RST_BUF[8] SLICE_WE_BUF[8] WL_slice
x5[7] EN_BUF VWL_SET ROW_SELECT[127] ROW_SELECT[126] ROW_SELECT[125] ROW_SELECT[124] ROW_SELECT[123]
+ ROW_SELECT[122] ROW_SELECT[121] ROW_SELECT[120] ROW_SELECT[119] ROW_SELECT[118] ROW_SELECT[117] ROW_SELECT[116]
+ ROW_SELECT[115] ROW_SELECT[114] ROW_SELECT[113] ROW_SELECT[112] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ
+ SET_RST_BUF VWL_FORM VDD WE_BUF VWL[127] VWL[126] VWL[125] VWL[124] VWL[123] VWL[122] VWL[121] VWL[120]
+ VWL[119] VWL[118] VWL[117] VWL[116] VWL[115] VWL[114] VWL[113] VWL[112] AVDD SLICE_ARRAY_EN_BUF[7]
+ SLICE_SET_FORM_BUF[7] SLICE_SET_RST_BUF[7] SLICE_WE_BUF[7] WL_slice
x5[6] EN_BUF VWL_SET ROW_SELECT[111] ROW_SELECT[110] ROW_SELECT[109] ROW_SELECT[108] ROW_SELECT[107]
+ ROW_SELECT[106] ROW_SELECT[105] ROW_SELECT[104] ROW_SELECT[103] ROW_SELECT[102] ROW_SELECT[101] ROW_SELECT[100]
+ ROW_SELECT[99] ROW_SELECT[98] ROW_SELECT[97] ROW_SELECT[96] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF
+ VWL_FORM VDD WE_BUF VWL[111] VWL[110] VWL[109] VWL[108] VWL[107] VWL[106] VWL[105] VWL[104] VWL[103]
+ VWL[102] VWL[101] VWL[100] VWL[99] VWL[98] VWL[97] VWL[96] AVDD SLICE_ARRAY_EN_BUF[6] SLICE_SET_FORM_BUF[6]
+ SLICE_SET_RST_BUF[6] SLICE_WE_BUF[6] WL_slice
x5[5] EN_BUF VWL_SET ROW_SELECT[95] ROW_SELECT[94] ROW_SELECT[93] ROW_SELECT[92] ROW_SELECT[91]
+ ROW_SELECT[90] ROW_SELECT[89] ROW_SELECT[88] ROW_SELECT[87] ROW_SELECT[86] ROW_SELECT[85] ROW_SELECT[84]
+ ROW_SELECT[83] ROW_SELECT[82] ROW_SELECT[81] ROW_SELECT[80] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF
+ VWL_FORM VDD WE_BUF VWL[95] VWL[94] VWL[93] VWL[92] VWL[91] VWL[90] VWL[89] VWL[88] VWL[87] VWL[86] VWL[85]
+ VWL[84] VWL[83] VWL[82] VWL[81] VWL[80] AVDD SLICE_ARRAY_EN_BUF[5] SLICE_SET_FORM_BUF[5]
+ SLICE_SET_RST_BUF[5] SLICE_WE_BUF[5] WL_slice
x5[4] EN_BUF VWL_SET ROW_SELECT[79] ROW_SELECT[78] ROW_SELECT[77] ROW_SELECT[76] ROW_SELECT[75]
+ ROW_SELECT[74] ROW_SELECT[73] ROW_SELECT[72] ROW_SELECT[71] ROW_SELECT[70] ROW_SELECT[69] ROW_SELECT[68]
+ ROW_SELECT[67] ROW_SELECT[66] ROW_SELECT[65] ROW_SELECT[64] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF
+ VWL_FORM VDD WE_BUF VWL[79] VWL[78] VWL[77] VWL[76] VWL[75] VWL[74] VWL[73] VWL[72] VWL[71] VWL[70] VWL[69]
+ VWL[68] VWL[67] VWL[66] VWL[65] VWL[64] AVDD SLICE_ARRAY_EN_BUF[4] SLICE_SET_FORM_BUF[4]
+ SLICE_SET_RST_BUF[4] SLICE_WE_BUF[4] WL_slice
x5[3] EN_BUF VWL_SET ROW_SELECT[63] ROW_SELECT[62] ROW_SELECT[61] ROW_SELECT[60] ROW_SELECT[59]
+ ROW_SELECT[58] ROW_SELECT[57] ROW_SELECT[56] ROW_SELECT[55] ROW_SELECT[54] ROW_SELECT[53] ROW_SELECT[52]
+ ROW_SELECT[51] ROW_SELECT[50] ROW_SELECT[49] ROW_SELECT[48] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF
+ VWL_FORM VDD WE_BUF VWL[63] VWL[62] VWL[61] VWL[60] VWL[59] VWL[58] VWL[57] VWL[56] VWL[55] VWL[54] VWL[53]
+ VWL[52] VWL[51] VWL[50] VWL[49] VWL[48] AVDD SLICE_ARRAY_EN_BUF[3] SLICE_SET_FORM_BUF[3]
+ SLICE_SET_RST_BUF[3] SLICE_WE_BUF[3] WL_slice
x5[2] EN_BUF VWL_SET ROW_SELECT[47] ROW_SELECT[46] ROW_SELECT[45] ROW_SELECT[44] ROW_SELECT[43]
+ ROW_SELECT[42] ROW_SELECT[41] ROW_SELECT[40] ROW_SELECT[39] ROW_SELECT[38] ROW_SELECT[37] ROW_SELECT[36]
+ ROW_SELECT[35] ROW_SELECT[34] ROW_SELECT[33] ROW_SELECT[32] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF
+ VWL_FORM VDD WE_BUF VWL[47] VWL[46] VWL[45] VWL[44] VWL[43] VWL[42] VWL[41] VWL[40] VWL[39] VWL[38] VWL[37]
+ VWL[36] VWL[35] VWL[34] VWL[33] VWL[32] AVDD SLICE_ARRAY_EN_BUF[2] SLICE_SET_FORM_BUF[2]
+ SLICE_SET_RST_BUF[2] SLICE_WE_BUF[2] WL_slice
x5[1] EN_BUF VWL_SET ROW_SELECT[31] ROW_SELECT[30] ROW_SELECT[29] ROW_SELECT[28] ROW_SELECT[27]
+ ROW_SELECT[26] ROW_SELECT[25] ROW_SELECT[24] ROW_SELECT[23] ROW_SELECT[22] ROW_SELECT[21] ROW_SELECT[20]
+ ROW_SELECT[19] ROW_SELECT[18] ROW_SELECT[17] ROW_SELECT[16] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF
+ VWL_FORM VDD WE_BUF VWL[31] VWL[30] VWL[29] VWL[28] VWL[27] VWL[26] VWL[25] VWL[24] VWL[23] VWL[22] VWL[21]
+ VWL[20] VWL[19] VWL[18] VWL[17] VWL[16] AVDD SLICE_ARRAY_EN_BUF[1] SLICE_SET_FORM_BUF[1]
+ SLICE_SET_RST_BUF[1] SLICE_WE_BUF[1] WL_slice
x5[0] EN_BUF VWL_SET ROW_SELECT[15] ROW_SELECT[14] ROW_SELECT[13] ROW_SELECT[12] ROW_SELECT[11]
+ ROW_SELECT[10] ROW_SELECT[9] ROW_SELECT[8] ROW_SELECT[7] ROW_SELECT[6] ROW_SELECT[5] ROW_SELECT[4] ROW_SELECT[3]
+ ROW_SELECT[2] ROW_SELECT[1] ROW_SELECT[0] VWL_RESET AVSS SET_FORM_BUF VSS VWL_READ SET_RST_BUF VWL_FORM VDD
+ WE_BUF VWL[15] VWL[14] VWL[13] VWL[12] VWL[11] VWL[10] VWL[9] VWL[8] VWL[7] VWL[6] VWL[5] VWL[4] VWL[3]
+ VWL[2] VWL[1] VWL[0] AVDD SLICE_ARRAY_EN_BUF[0] SLICE_SET_FORM_BUF[0] SLICE_SET_RST_BUF[0] SLICE_WE_BUF[0]
+ WL_slice
x4 SET_RST VSS VSS VDD VDD SET_RST_BUF sky130_fd_sc_hd__buf_4
x6 WE VSS VSS VDD VDD WE_BUF sky130_fd_sc_hd__buf_4
x2 VSS A_BUF[7] A_BUF[6] A_BUF[5] A_BUF[4] A_BUF[3] A_BUF[2] A_BUF[1] A_BUF[0] ROW_SELECT[255]
+ ROW_SELECT[254] ROW_SELECT[253] ROW_SELECT[252] ROW_SELECT[251] ROW_SELECT[250] ROW_SELECT[249] ROW_SELECT[248]
+ ROW_SELECT[247] ROW_SELECT[246] ROW_SELECT[245] ROW_SELECT[244] ROW_SELECT[243] ROW_SELECT[242] ROW_SELECT[241]
+ ROW_SELECT[240] ROW_SELECT[239] ROW_SELECT[238] ROW_SELECT[237] ROW_SELECT[236] ROW_SELECT[235] ROW_SELECT[234]
+ ROW_SELECT[233] ROW_SELECT[232] ROW_SELECT[231] ROW_SELECT[230] ROW_SELECT[229] ROW_SELECT[228] ROW_SELECT[227]
+ ROW_SELECT[226] ROW_SELECT[225] ROW_SELECT[224] ROW_SELECT[223] ROW_SELECT[222] ROW_SELECT[221] ROW_SELECT[220]
+ ROW_SELECT[219] ROW_SELECT[218] ROW_SELECT[217] ROW_SELECT[216] ROW_SELECT[215] ROW_SELECT[214] ROW_SELECT[213]
+ ROW_SELECT[212] ROW_SELECT[211] ROW_SELECT[210] ROW_SELECT[209] ROW_SELECT[208] ROW_SELECT[207] ROW_SELECT[206]
+ ROW_SELECT[205] ROW_SELECT[204] ROW_SELECT[203] ROW_SELECT[202] ROW_SELECT[201] ROW_SELECT[200] ROW_SELECT[199]
+ ROW_SELECT[198] ROW_SELECT[197] ROW_SELECT[196] ROW_SELECT[195] ROW_SELECT[194] ROW_SELECT[193] ROW_SELECT[192]
+ ROW_SELECT[191] ROW_SELECT[190] ROW_SELECT[189] ROW_SELECT[188] ROW_SELECT[187] ROW_SELECT[186] ROW_SELECT[185]
+ ROW_SELECT[184] ROW_SELECT[183] ROW_SELECT[182] ROW_SELECT[181] ROW_SELECT[180] ROW_SELECT[179] ROW_SELECT[178]
+ ROW_SELECT[177] ROW_SELECT[176] ROW_SELECT[175] ROW_SELECT[174] ROW_SELECT[173] ROW_SELECT[172] ROW_SELECT[171]
+ ROW_SELECT[170] ROW_SELECT[169] ROW_SELECT[168] ROW_SELECT[167] ROW_SELECT[166] ROW_SELECT[165] ROW_SELECT[164]
+ ROW_SELECT[163] ROW_SELECT[162] ROW_SELECT[161] ROW_SELECT[160] ROW_SELECT[159] ROW_SELECT[158] ROW_SELECT[157]
+ ROW_SELECT[156] ROW_SELECT[155] ROW_SELECT[154] ROW_SELECT[153] ROW_SELECT[152] ROW_SELECT[151] ROW_SELECT[150]
+ ROW_SELECT[149] ROW_SELECT[148] ROW_SELECT[147] ROW_SELECT[146] ROW_SELECT[145] ROW_SELECT[144] ROW_SELECT[143]
+ ROW_SELECT[142] ROW_SELECT[141] ROW_SELECT[140] ROW_SELECT[139] ROW_SELECT[138] ROW_SELECT[137] ROW_SELECT[136]
+ ROW_SELECT[135] ROW_SELECT[134] ROW_SELECT[133] ROW_SELECT[132] ROW_SELECT[131] ROW_SELECT[130] ROW_SELECT[129]
+ ROW_SELECT[128] ROW_SELECT[127] ROW_SELECT[126] ROW_SELECT[125] ROW_SELECT[124] ROW_SELECT[123] ROW_SELECT[122]
+ ROW_SELECT[121] ROW_SELECT[120] ROW_SELECT[119] ROW_SELECT[118] ROW_SELECT[117] ROW_SELECT[116] ROW_SELECT[115]
+ ROW_SELECT[114] ROW_SELECT[113] ROW_SELECT[112] ROW_SELECT[111] ROW_SELECT[110] ROW_SELECT[109] ROW_SELECT[108]
+ ROW_SELECT[107] ROW_SELECT[106] ROW_SELECT[105] ROW_SELECT[104] ROW_SELECT[103] ROW_SELECT[102] ROW_SELECT[101]
+ ROW_SELECT[100] ROW_SELECT[99] ROW_SELECT[98] ROW_SELECT[97] ROW_SELECT[96] ROW_SELECT[95] ROW_SELECT[94]
+ ROW_SELECT[93] ROW_SELECT[92] ROW_SELECT[91] ROW_SELECT[90] ROW_SELECT[89] ROW_SELECT[88] ROW_SELECT[87]
+ ROW_SELECT[86] ROW_SELECT[85] ROW_SELECT[84] ROW_SELECT[83] ROW_SELECT[82] ROW_SELECT[81] ROW_SELECT[80]
+ ROW_SELECT[79] ROW_SELECT[78] ROW_SELECT[77] ROW_SELECT[76] ROW_SELECT[75] ROW_SELECT[74] ROW_SELECT[73]
+ ROW_SELECT[72] ROW_SELECT[71] ROW_SELECT[70] ROW_SELECT[69] ROW_SELECT[68] ROW_SELECT[67] ROW_SELECT[66]
+ ROW_SELECT[65] ROW_SELECT[64] ROW_SELECT[63] ROW_SELECT[62] ROW_SELECT[61] ROW_SELECT[60] ROW_SELECT[59]
+ ROW_SELECT[58] ROW_SELECT[57] ROW_SELECT[56] ROW_SELECT[55] ROW_SELECT[54] ROW_SELECT[53] ROW_SELECT[52]
+ ROW_SELECT[51] ROW_SELECT[50] ROW_SELECT[49] ROW_SELECT[48] ROW_SELECT[47] ROW_SELECT[46] ROW_SELECT[45]
+ ROW_SELECT[44] ROW_SELECT[43] ROW_SELECT[42] ROW_SELECT[41] ROW_SELECT[40] ROW_SELECT[39] ROW_SELECT[38]
+ ROW_SELECT[37] ROW_SELECT[36] ROW_SELECT[35] ROW_SELECT[34] ROW_SELECT[33] ROW_SELECT[32] ROW_SELECT[31]
+ ROW_SELECT[30] ROW_SELECT[29] ROW_SELECT[28] ROW_SELECT[27] ROW_SELECT[26] ROW_SELECT[25] ROW_SELECT[24]
+ ROW_SELECT[23] ROW_SELECT[22] ROW_SELECT[21] ROW_SELECT[20] ROW_SELECT[19] ROW_SELECT[18] ROW_SELECT[17]
+ ROW_SELECT[16] ROW_SELECT[15] ROW_SELECT[14] ROW_SELECT[13] ROW_SELECT[12] ROW_SELECT[11] ROW_SELECT[10]
+ ROW_SELECT[9] ROW_SELECT[8] ROW_SELECT[7] ROW_SELECT[6] ROW_SELECT[5] ROW_SELECT[4] ROW_SELECT[3] ROW_SELECT[2]
+ ROW_SELECT[1] ROW_SELECT[0] VDD 8_to_256_decoder
**.ends

* expanding   symbol:  WL_Interface/WL_slice.sym # of pins=18
** sym_path: WL_Interface/WL_slice.sym
** sch_path: WL_Interface/WL_slice.sch
.subckt WL_slice EN VWL_SET SELECT[15] SELECT[14] SELECT[13] SELECT[12] SELECT[11] SELECT[10]
+ SELECT[9] SELECT[8] SELECT[7] SELECT[6] SELECT[5] SELECT[4] SELECT[3] SELECT[2] SELECT[1] SELECT[0] VWL_RST
+ AVSS SET_FORM VSS VWL_READ SET_RST VWL_FORM VDD WE VWL[15] VWL[14] VWL[13] VWL[12] VWL[11] VWL[10]
+ VWL[9] VWL[8] VWL[7] VWL[6] VWL[5] VWL[4] VWL[3] VWL[2] VWL[1] VWL[0] AVDD ARRAY_EN_BUF SET_FORM_BUF
+ SET_RST_BUF WE_BUF
*.ipin AVSS
*.ipin VSS
*.ipin VDD
*.ipin AVDD
*.ipin
*+ SELECT[15],SELECT[14],SELECT[13],SELECT[12],SELECT[11],SELECT[10],SELECT[9],SELECT[8],SELECT[7],SELECT[6],SELECT[5],SELECT[4],SELECT[3],SELECT[2],SELECT[1],SELECT[0]
*.ipin SET_FORM
*.ipin SET_RST
*.ipin WE
*.ipin EN
*.iopin VWL_SET
*.iopin VWL_RST
*.iopin VWL_READ
*.iopin VWL_FORM
*.iopin
*+ VWL[15],VWL[14],VWL[13],VWL[12],VWL[11],VWL[10],VWL[9],VWL[8],VWL[7],VWL[6],VWL[5],VWL[4],VWL[3],VWL[2],VWL[1],VWL[0]
*.opin ARRAY_EN_BUF
*.opin SET_FORM_BUF
*.opin SET_RST_BUF
*.opin WE_BUF
x1 EN VSS VSS VDD VDD ARRAY_EN_BUF sky130_fd_sc_hd__bufbuf_8
x2 SET_FORM VSS VSS VDD VDD SET_FORM_BUF sky130_fd_sc_hd__bufbuf_16
x3 SET_RST VSS VSS VDD VDD SET_RST_BUF sky130_fd_sc_hd__bufbuf_16
x4 WE VSS VSS VDD VDD WE_BUF sky130_fd_sc_hd__bufbuf_16
x1[15] SELECT[15] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF
+ AVDD VWL[15] ARRAY_EN_BUF WL_driver
x1[14] SELECT[14] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF
+ AVDD VWL[14] ARRAY_EN_BUF WL_driver
x1[13] SELECT[13] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF
+ AVDD VWL[13] ARRAY_EN_BUF WL_driver
x1[12] SELECT[12] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF
+ AVDD VWL[12] ARRAY_EN_BUF WL_driver
x1[11] SELECT[11] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF
+ AVDD VWL[11] ARRAY_EN_BUF WL_driver
x1[10] SELECT[10] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF
+ AVDD VWL[10] ARRAY_EN_BUF WL_driver
x1[9] SELECT[9] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[9] ARRAY_EN_BUF WL_driver
x1[8] SELECT[8] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[8] ARRAY_EN_BUF WL_driver
x1[7] SELECT[7] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[7] ARRAY_EN_BUF WL_driver
x1[6] SELECT[6] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[6] ARRAY_EN_BUF WL_driver
x1[5] SELECT[5] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[5] ARRAY_EN_BUF WL_driver
x1[4] SELECT[4] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[4] ARRAY_EN_BUF WL_driver
x1[3] SELECT[3] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[3] ARRAY_EN_BUF WL_driver
x1[2] SELECT[2] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[2] ARRAY_EN_BUF WL_driver
x1[1] SELECT[1] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[1] ARRAY_EN_BUF WL_driver
x1[0] SELECT[0] AVSS VWL_SET VSS VWL_RST SET_FORM_BUF SET_RST_BUF VDD VWL_READ VWL_FORM WE_BUF AVDD
+ VWL[0] ARRAY_EN_BUF WL_driver
.ends


* expanding   symbol:  WL_Interface/8_to_256_decoder.sym # of pins=4
** sym_path: WL_Interface/8_to_256_decoder.sym
** sch_path: WL_Interface/8_to_256_decoder.sch
.subckt 8_to_256_decoder VSS IN[7] IN[6] IN[5] IN[4] IN[3] IN[2] IN[1] IN[0] OUT[255] OUT[254]
+ OUT[253] OUT[252] OUT[251] OUT[250] OUT[249] OUT[248] OUT[247] OUT[246] OUT[245] OUT[244] OUT[243] OUT[242]
+ OUT[241] OUT[240] OUT[239] OUT[238] OUT[237] OUT[236] OUT[235] OUT[234] OUT[233] OUT[232] OUT[231] OUT[230]
+ OUT[229] OUT[228] OUT[227] OUT[226] OUT[225] OUT[224] OUT[223] OUT[222] OUT[221] OUT[220] OUT[219] OUT[218]
+ OUT[217] OUT[216] OUT[215] OUT[214] OUT[213] OUT[212] OUT[211] OUT[210] OUT[209] OUT[208] OUT[207] OUT[206]
+ OUT[205] OUT[204] OUT[203] OUT[202] OUT[201] OUT[200] OUT[199] OUT[198] OUT[197] OUT[196] OUT[195] OUT[194]
+ OUT[193] OUT[192] OUT[191] OUT[190] OUT[189] OUT[188] OUT[187] OUT[186] OUT[185] OUT[184] OUT[183] OUT[182]
+ OUT[181] OUT[180] OUT[179] OUT[178] OUT[177] OUT[176] OUT[175] OUT[174] OUT[173] OUT[172] OUT[171] OUT[170]
+ OUT[169] OUT[168] OUT[167] OUT[166] OUT[165] OUT[164] OUT[163] OUT[162] OUT[161] OUT[160] OUT[159] OUT[158]
+ OUT[157] OUT[156] OUT[155] OUT[154] OUT[153] OUT[152] OUT[151] OUT[150] OUT[149] OUT[148] OUT[147] OUT[146]
+ OUT[145] OUT[144] OUT[143] OUT[142] OUT[141] OUT[140] OUT[139] OUT[138] OUT[137] OUT[136] OUT[135] OUT[134]
+ OUT[133] OUT[132] OUT[131] OUT[130] OUT[129] OUT[128] OUT[127] OUT[126] OUT[125] OUT[124] OUT[123] OUT[122]
+ OUT[121] OUT[120] OUT[119] OUT[118] OUT[117] OUT[116] OUT[115] OUT[114] OUT[113] OUT[112] OUT[111] OUT[110]
+ OUT[109] OUT[108] OUT[107] OUT[106] OUT[105] OUT[104] OUT[103] OUT[102] OUT[101] OUT[100] OUT[99] OUT[98]
+ OUT[97] OUT[96] OUT[95] OUT[94] OUT[93] OUT[92] OUT[91] OUT[90] OUT[89] OUT[88] OUT[87] OUT[86] OUT[85]
+ OUT[84] OUT[83] OUT[82] OUT[81] OUT[80] OUT[79] OUT[78] OUT[77] OUT[76] OUT[75] OUT[74] OUT[73] OUT[72]
+ OUT[71] OUT[70] OUT[69] OUT[68] OUT[67] OUT[66] OUT[65] OUT[64] OUT[63] OUT[62] OUT[61] OUT[60] OUT[59]
+ OUT[58] OUT[57] OUT[56] OUT[55] OUT[54] OUT[53] OUT[52] OUT[51] OUT[50] OUT[49] OUT[48] OUT[47] OUT[46]
+ OUT[45] OUT[44] OUT[43] OUT[42] OUT[41] OUT[40] OUT[39] OUT[38] OUT[37] OUT[36] OUT[35] OUT[34] OUT[33]
+ OUT[32] OUT[31] OUT[30] OUT[29] OUT[28] OUT[27] OUT[26] OUT[25] OUT[24] OUT[23] OUT[22] OUT[21] OUT[20]
+ OUT[19] OUT[18] OUT[17] OUT[16] OUT[15] OUT[14] OUT[13] OUT[12] OUT[11] OUT[10] OUT[9] OUT[8] OUT[7] OUT[6]
+ OUT[5] OUT[4] OUT[3] OUT[2] OUT[1] OUT[0] VDD
*.ipin VSS
*.ipin VDD
*.opin
*+ OUT[255],OUT[254],OUT[253],OUT[252],OUT[251],OUT[250],OUT[249],OUT[248],OUT[247],OUT[246],OUT[245],OUT[244],OUT[243],OUT[242],OUT[241],OUT[240],OUT[239],OUT[238],OUT[237],OUT[236],OUT[235],OUT[234],OUT[233],OUT[232],OUT[231],OUT[230],OUT[229],OUT[228],OUT[227],OUT[226],OUT[225],OUT[224],OUT[223],OUT[222],OUT[221],OUT[220],OUT[219],OUT[218],OUT[217],OUT[216],OUT[215],OUT[214],OUT[213],OUT[212],OUT[211],OUT[210],OUT[209],OUT[208],OUT[207],OUT[206],OUT[205],OUT[204],OUT[203],OUT[202],OUT[201],OUT[200],OUT[199],OUT[198],OUT[197],OUT[196],OUT[195],OUT[194],OUT[193],OUT[192],OUT[191],OUT[190],OUT[189],OUT[188],OUT[187],OUT[186],OUT[185],OUT[184],OUT[183],OUT[182],OUT[181],OUT[180],OUT[179],OUT[178],OUT[177],OUT[176],OUT[175],OUT[174],OUT[173],OUT[172],OUT[171],OUT[170],OUT[169],OUT[168],OUT[167],OUT[166],OUT[165],OUT[164],OUT[163],OUT[162],OUT[161],OUT[160],OUT[159],OUT[158],OUT[157],OUT[156],OUT[155],OUT[154],OUT[153],OUT[152],OUT[151],OUT[150],OUT[149],OUT[148],OUT[147],OUT[146],OUT[145],OUT[144],OUT[143],OUT[142],OUT[141],OUT[140],OUT[139],OUT[138],OUT[137],OUT[136],OUT[135],OUT[134],OUT[133],OUT[132],OUT[131],OUT[130],OUT[129],OUT[128],OUT[127],OUT[126],OUT[125],OUT[124],OUT[123],OUT[122],OUT[121],OUT[120],OUT[119],OUT[118],OUT[117],OUT[116],OUT[115],OUT[114],OUT[113],OUT[112],OUT[111],OUT[110],OUT[109],OUT[108],OUT[107],OUT[106],OUT[105],OUT[104],OUT[103],OUT[102],OUT[101],OUT[100],OUT[99],OUT[98],OUT[97],OUT[96],OUT[95],OUT[94],OUT[93],OUT[92],OUT[91],OUT[90],OUT[89],OUT[88],OUT[87],OUT[86],OUT[85],OUT[84],OUT[83],OUT[82],OUT[81],OUT[80],OUT[79],OUT[78],OUT[77],OUT[76],OUT[75],OUT[74],OUT[73],OUT[72],OUT[71],OUT[70],OUT[69],OUT[68],OUT[67],OUT[66],OUT[65],OUT[64],OUT[63],OUT[62],OUT[61],OUT[60],OUT[59],OUT[58],OUT[57],OUT[56],OUT[55],OUT[54],OUT[53],OUT[52],OUT[51],OUT[50],OUT[49],OUT[48],OUT[47],OUT[46],OUT[45],OUT[44],OUT[43],OUT[42],OUT[41],OUT[40],OUT[39],OUT[38],OUT[37],OUT[36],OUT[35],OUT[34],OUT[33],OUT[32],OUT[31],OUT[30],OUT[29],OUT[28],OUT[27],OUT[26],OUT[25],OUT[24],OUT[23],OUT[22],OUT[21],OUT[20],OUT[19],OUT[18],OUT[17],OUT[16],OUT[15],OUT[14],OUT[13],OUT[12],OUT[11],OUT[10],OUT[9],OUT[8],OUT[7],OUT[6],OUT[5],OUT[4],OUT[3],OUT[2],OUT[1],OUT[0]
*.ipin IN[7],IN[6],IN[5],IN[4],IN[3],IN[2],IN[1],IN[0]
x1 IN[7] IN[6] VSS VSS VDD VDD C[3] sky130_fd_sc_hd__and2_4
x2 IN[6] IN[7] VSS VSS VDD VDD C[2] sky130_fd_sc_hd__and2b_4
x4 IN[7] IN[6] VSS VSS VDD VDD C[0] sky130_fd_sc_hd__nor2_4
x3 IN[7] IN[6] VSS VSS VDD VDD C[1] sky130_fd_sc_hd__and2b_4
x5 IN[5] IN[4] VSS VSS VDD VDD D[3] sky130_fd_sc_hd__and2_4
x6 IN[4] IN[5] VSS VSS VDD VDD D[2] sky130_fd_sc_hd__and2b_4
x7 IN[5] IN[4] VSS VSS VDD VDD D[1] sky130_fd_sc_hd__and2b_4
x8 IN[5] IN[4] VSS VSS VDD VDD D[0] sky130_fd_sc_hd__nor2_4
x9 IN[3] IN[2] VSS VSS VDD VDD E[3] sky130_fd_sc_hd__and2_4
x10 IN[2] IN[3] VSS VSS VDD VDD E[2] sky130_fd_sc_hd__and2b_4
x11 IN[3] IN[2] VSS VSS VDD VDD E[1] sky130_fd_sc_hd__and2b_4
x12 IN[3] IN[2] VSS VSS VDD VDD E[0] sky130_fd_sc_hd__nor2_4
x13 IN[1] IN[0] VSS VSS VDD VDD F[3] sky130_fd_sc_hd__and2_4
x14 IN[0] IN[1] VSS VSS VDD VDD F[2] sky130_fd_sc_hd__and2b_4
x15 IN[1] IN[0] VSS VSS VDD VDD F[1] sky130_fd_sc_hd__and2b_4
x16 IN[1] IN[0] VSS VSS VDD VDD F[0] sky130_fd_sc_hd__nor2_4
x2[3] C[2] D[3] VSS VSS VDD VDD A[11] sky130_fd_sc_hd__and2_4
x2[2] C[2] D[2] VSS VSS VDD VDD A[10] sky130_fd_sc_hd__and2_4
x2[1] C[2] D[1] VSS VSS VDD VDD A[9] sky130_fd_sc_hd__and2_4
x2[0] C[2] D[0] VSS VSS VDD VDD A[8] sky130_fd_sc_hd__and2_4
x1[3] C[3] D[3] VSS VSS VDD VDD A[15] sky130_fd_sc_hd__and2_4
x1[2] C[3] D[2] VSS VSS VDD VDD A[14] sky130_fd_sc_hd__and2_4
x1[1] C[3] D[1] VSS VSS VDD VDD A[13] sky130_fd_sc_hd__and2_4
x1[0] C[3] D[0] VSS VSS VDD VDD A[12] sky130_fd_sc_hd__and2_4
x3[3] C[1] D[3] VSS VSS VDD VDD A[7] sky130_fd_sc_hd__and2_4
x3[2] C[1] D[2] VSS VSS VDD VDD A[6] sky130_fd_sc_hd__and2_4
x3[1] C[1] D[1] VSS VSS VDD VDD A[5] sky130_fd_sc_hd__and2_4
x3[0] C[1] D[0] VSS VSS VDD VDD A[4] sky130_fd_sc_hd__and2_4
x4[3] C[0] D[3] VSS VSS VDD VDD A[3] sky130_fd_sc_hd__and2_4
x4[2] C[0] D[2] VSS VSS VDD VDD A[2] sky130_fd_sc_hd__and2_4
x4[1] C[0] D[1] VSS VSS VDD VDD A[1] sky130_fd_sc_hd__and2_4
x4[0] C[0] D[0] VSS VSS VDD VDD A[0] sky130_fd_sc_hd__and2_4
x5[3] E[2] F[3] VSS VSS VDD VDD B[11] sky130_fd_sc_hd__and2_4
x5[2] E[2] F[2] VSS VSS VDD VDD B[10] sky130_fd_sc_hd__and2_4
x5[1] E[2] F[1] VSS VSS VDD VDD B[9] sky130_fd_sc_hd__and2_4
x5[0] E[2] F[0] VSS VSS VDD VDD B[8] sky130_fd_sc_hd__and2_4
x6[3] E[3] F[3] VSS VSS VDD VDD B[15] sky130_fd_sc_hd__and2_4
x6[2] E[3] F[2] VSS VSS VDD VDD B[14] sky130_fd_sc_hd__and2_4
x6[1] E[3] F[1] VSS VSS VDD VDD B[13] sky130_fd_sc_hd__and2_4
x6[0] E[3] F[0] VSS VSS VDD VDD B[12] sky130_fd_sc_hd__and2_4
x7[3] E[1] F[3] VSS VSS VDD VDD B[7] sky130_fd_sc_hd__and2_4
x7[2] E[1] F[2] VSS VSS VDD VDD B[6] sky130_fd_sc_hd__and2_4
x7[1] E[1] F[1] VSS VSS VDD VDD B[5] sky130_fd_sc_hd__and2_4
x7[0] E[1] F[0] VSS VSS VDD VDD B[4] sky130_fd_sc_hd__and2_4
x8[3] E[0] F[3] VSS VSS VDD VDD B[3] sky130_fd_sc_hd__and2_4
x8[2] E[0] F[2] VSS VSS VDD VDD B[2] sky130_fd_sc_hd__and2_4
x8[1] E[0] F[1] VSS VSS VDD VDD B[1] sky130_fd_sc_hd__and2_4
x8[0] E[0] F[0] VSS VSS VDD VDD B[0] sky130_fd_sc_hd__and2_4
x1[15] A[15] B[15] VSS VSS VDD VDD OUT[255] sky130_fd_sc_hd__and2_0
x1[14] A[15] B[14] VSS VSS VDD VDD OUT[254] sky130_fd_sc_hd__and2_0
x1[13] A[15] B[13] VSS VSS VDD VDD OUT[253] sky130_fd_sc_hd__and2_0
x1[12] A[15] B[12] VSS VSS VDD VDD OUT[252] sky130_fd_sc_hd__and2_0
x1[11] A[15] B[11] VSS VSS VDD VDD OUT[251] sky130_fd_sc_hd__and2_0
x1[10] A[15] B[10] VSS VSS VDD VDD OUT[250] sky130_fd_sc_hd__and2_0
x1[9] A[15] B[9] VSS VSS VDD VDD OUT[249] sky130_fd_sc_hd__and2_0
x1[8] A[15] B[8] VSS VSS VDD VDD OUT[248] sky130_fd_sc_hd__and2_0
x1[7] A[15] B[7] VSS VSS VDD VDD OUT[247] sky130_fd_sc_hd__and2_0
x1[6] A[15] B[6] VSS VSS VDD VDD OUT[246] sky130_fd_sc_hd__and2_0
x1[5] A[15] B[5] VSS VSS VDD VDD OUT[245] sky130_fd_sc_hd__and2_0
x1[4] A[15] B[4] VSS VSS VDD VDD OUT[244] sky130_fd_sc_hd__and2_0
x1[3] A[15] B[3] VSS VSS VDD VDD OUT[243] sky130_fd_sc_hd__and2_0
x1[2] A[15] B[2] VSS VSS VDD VDD OUT[242] sky130_fd_sc_hd__and2_0
x1[1] A[15] B[1] VSS VSS VDD VDD OUT[241] sky130_fd_sc_hd__and2_0
x1[0] A[15] B[0] VSS VSS VDD VDD OUT[240] sky130_fd_sc_hd__and2_0
x2[15] A[14] B[15] VSS VSS VDD VDD OUT[239] sky130_fd_sc_hd__and2_0
x2[14] A[14] B[14] VSS VSS VDD VDD OUT[238] sky130_fd_sc_hd__and2_0
x2[13] A[14] B[13] VSS VSS VDD VDD OUT[237] sky130_fd_sc_hd__and2_0
x2[12] A[14] B[12] VSS VSS VDD VDD OUT[236] sky130_fd_sc_hd__and2_0
x2[11] A[14] B[11] VSS VSS VDD VDD OUT[235] sky130_fd_sc_hd__and2_0
x2[10] A[14] B[10] VSS VSS VDD VDD OUT[234] sky130_fd_sc_hd__and2_0
x2[9] A[14] B[9] VSS VSS VDD VDD OUT[233] sky130_fd_sc_hd__and2_0
x2[8] A[14] B[8] VSS VSS VDD VDD OUT[232] sky130_fd_sc_hd__and2_0
x2[7] A[14] B[7] VSS VSS VDD VDD OUT[231] sky130_fd_sc_hd__and2_0
x2[6] A[14] B[6] VSS VSS VDD VDD OUT[230] sky130_fd_sc_hd__and2_0
x2[5] A[14] B[5] VSS VSS VDD VDD OUT[229] sky130_fd_sc_hd__and2_0
x2[4] A[14] B[4] VSS VSS VDD VDD OUT[228] sky130_fd_sc_hd__and2_0
x2[3] A[14] B[3] VSS VSS VDD VDD OUT[227] sky130_fd_sc_hd__and2_0
x2[2] A[14] B[2] VSS VSS VDD VDD OUT[226] sky130_fd_sc_hd__and2_0
x2[1] A[14] B[1] VSS VSS VDD VDD OUT[225] sky130_fd_sc_hd__and2_0
x2[0] A[14] B[0] VSS VSS VDD VDD OUT[224] sky130_fd_sc_hd__and2_0
x3[15] A[13] B[15] VSS VSS VDD VDD OUT[223] sky130_fd_sc_hd__and2_0
x3[14] A[13] B[14] VSS VSS VDD VDD OUT[222] sky130_fd_sc_hd__and2_0
x3[13] A[13] B[13] VSS VSS VDD VDD OUT[221] sky130_fd_sc_hd__and2_0
x3[12] A[13] B[12] VSS VSS VDD VDD OUT[220] sky130_fd_sc_hd__and2_0
x3[11] A[13] B[11] VSS VSS VDD VDD OUT[219] sky130_fd_sc_hd__and2_0
x3[10] A[13] B[10] VSS VSS VDD VDD OUT[218] sky130_fd_sc_hd__and2_0
x3[9] A[13] B[9] VSS VSS VDD VDD OUT[217] sky130_fd_sc_hd__and2_0
x3[8] A[13] B[8] VSS VSS VDD VDD OUT[216] sky130_fd_sc_hd__and2_0
x3[7] A[13] B[7] VSS VSS VDD VDD OUT[215] sky130_fd_sc_hd__and2_0
x3[6] A[13] B[6] VSS VSS VDD VDD OUT[214] sky130_fd_sc_hd__and2_0
x3[5] A[13] B[5] VSS VSS VDD VDD OUT[213] sky130_fd_sc_hd__and2_0
x3[4] A[13] B[4] VSS VSS VDD VDD OUT[212] sky130_fd_sc_hd__and2_0
x3[3] A[13] B[3] VSS VSS VDD VDD OUT[211] sky130_fd_sc_hd__and2_0
x3[2] A[13] B[2] VSS VSS VDD VDD OUT[210] sky130_fd_sc_hd__and2_0
x3[1] A[13] B[1] VSS VSS VDD VDD OUT[209] sky130_fd_sc_hd__and2_0
x3[0] A[13] B[0] VSS VSS VDD VDD OUT[208] sky130_fd_sc_hd__and2_0
x4[15] A[12] B[15] VSS VSS VDD VDD OUT[207] sky130_fd_sc_hd__and2_0
x4[14] A[12] B[14] VSS VSS VDD VDD OUT[206] sky130_fd_sc_hd__and2_0
x4[13] A[12] B[13] VSS VSS VDD VDD OUT[205] sky130_fd_sc_hd__and2_0
x4[12] A[12] B[12] VSS VSS VDD VDD OUT[204] sky130_fd_sc_hd__and2_0
x4[11] A[12] B[11] VSS VSS VDD VDD OUT[203] sky130_fd_sc_hd__and2_0
x4[10] A[12] B[10] VSS VSS VDD VDD OUT[202] sky130_fd_sc_hd__and2_0
x4[9] A[12] B[9] VSS VSS VDD VDD OUT[201] sky130_fd_sc_hd__and2_0
x4[8] A[12] B[8] VSS VSS VDD VDD OUT[200] sky130_fd_sc_hd__and2_0
x4[7] A[12] B[7] VSS VSS VDD VDD OUT[199] sky130_fd_sc_hd__and2_0
x4[6] A[12] B[6] VSS VSS VDD VDD OUT[198] sky130_fd_sc_hd__and2_0
x4[5] A[12] B[5] VSS VSS VDD VDD OUT[197] sky130_fd_sc_hd__and2_0
x4[4] A[12] B[4] VSS VSS VDD VDD OUT[196] sky130_fd_sc_hd__and2_0
x4[3] A[12] B[3] VSS VSS VDD VDD OUT[195] sky130_fd_sc_hd__and2_0
x4[2] A[12] B[2] VSS VSS VDD VDD OUT[194] sky130_fd_sc_hd__and2_0
x4[1] A[12] B[1] VSS VSS VDD VDD OUT[193] sky130_fd_sc_hd__and2_0
x4[0] A[12] B[0] VSS VSS VDD VDD OUT[192] sky130_fd_sc_hd__and2_0
x5[15] A[11] B[15] VSS VSS VDD VDD OUT[191] sky130_fd_sc_hd__and2_0
x5[14] A[11] B[14] VSS VSS VDD VDD OUT[190] sky130_fd_sc_hd__and2_0
x5[13] A[11] B[13] VSS VSS VDD VDD OUT[189] sky130_fd_sc_hd__and2_0
x5[12] A[11] B[12] VSS VSS VDD VDD OUT[188] sky130_fd_sc_hd__and2_0
x5[11] A[11] B[11] VSS VSS VDD VDD OUT[187] sky130_fd_sc_hd__and2_0
x5[10] A[11] B[10] VSS VSS VDD VDD OUT[186] sky130_fd_sc_hd__and2_0
x5[9] A[11] B[9] VSS VSS VDD VDD OUT[185] sky130_fd_sc_hd__and2_0
x5[8] A[11] B[8] VSS VSS VDD VDD OUT[184] sky130_fd_sc_hd__and2_0
x5[7] A[11] B[7] VSS VSS VDD VDD OUT[183] sky130_fd_sc_hd__and2_0
x5[6] A[11] B[6] VSS VSS VDD VDD OUT[182] sky130_fd_sc_hd__and2_0
x5[5] A[11] B[5] VSS VSS VDD VDD OUT[181] sky130_fd_sc_hd__and2_0
x5[4] A[11] B[4] VSS VSS VDD VDD OUT[180] sky130_fd_sc_hd__and2_0
x5[3] A[11] B[3] VSS VSS VDD VDD OUT[179] sky130_fd_sc_hd__and2_0
x5[2] A[11] B[2] VSS VSS VDD VDD OUT[178] sky130_fd_sc_hd__and2_0
x5[1] A[11] B[1] VSS VSS VDD VDD OUT[177] sky130_fd_sc_hd__and2_0
x5[0] A[11] B[0] VSS VSS VDD VDD OUT[176] sky130_fd_sc_hd__and2_0
x6[15] A[10] B[15] VSS VSS VDD VDD OUT[175] sky130_fd_sc_hd__and2_0
x6[14] A[10] B[14] VSS VSS VDD VDD OUT[174] sky130_fd_sc_hd__and2_0
x6[13] A[10] B[13] VSS VSS VDD VDD OUT[173] sky130_fd_sc_hd__and2_0
x6[12] A[10] B[12] VSS VSS VDD VDD OUT[172] sky130_fd_sc_hd__and2_0
x6[11] A[10] B[11] VSS VSS VDD VDD OUT[171] sky130_fd_sc_hd__and2_0
x6[10] A[10] B[10] VSS VSS VDD VDD OUT[170] sky130_fd_sc_hd__and2_0
x6[9] A[10] B[9] VSS VSS VDD VDD OUT[169] sky130_fd_sc_hd__and2_0
x6[8] A[10] B[8] VSS VSS VDD VDD OUT[168] sky130_fd_sc_hd__and2_0
x6[7] A[10] B[7] VSS VSS VDD VDD OUT[167] sky130_fd_sc_hd__and2_0
x6[6] A[10] B[6] VSS VSS VDD VDD OUT[166] sky130_fd_sc_hd__and2_0
x6[5] A[10] B[5] VSS VSS VDD VDD OUT[165] sky130_fd_sc_hd__and2_0
x6[4] A[10] B[4] VSS VSS VDD VDD OUT[164] sky130_fd_sc_hd__and2_0
x6[3] A[10] B[3] VSS VSS VDD VDD OUT[163] sky130_fd_sc_hd__and2_0
x6[2] A[10] B[2] VSS VSS VDD VDD OUT[162] sky130_fd_sc_hd__and2_0
x6[1] A[10] B[1] VSS VSS VDD VDD OUT[161] sky130_fd_sc_hd__and2_0
x6[0] A[10] B[0] VSS VSS VDD VDD OUT[160] sky130_fd_sc_hd__and2_0
x7[15] A[9] B[15] VSS VSS VDD VDD OUT[159] sky130_fd_sc_hd__and2_0
x7[14] A[9] B[14] VSS VSS VDD VDD OUT[158] sky130_fd_sc_hd__and2_0
x7[13] A[9] B[13] VSS VSS VDD VDD OUT[157] sky130_fd_sc_hd__and2_0
x7[12] A[9] B[12] VSS VSS VDD VDD OUT[156] sky130_fd_sc_hd__and2_0
x7[11] A[9] B[11] VSS VSS VDD VDD OUT[155] sky130_fd_sc_hd__and2_0
x7[10] A[9] B[10] VSS VSS VDD VDD OUT[154] sky130_fd_sc_hd__and2_0
x7[9] A[9] B[9] VSS VSS VDD VDD OUT[153] sky130_fd_sc_hd__and2_0
x7[8] A[9] B[8] VSS VSS VDD VDD OUT[152] sky130_fd_sc_hd__and2_0
x7[7] A[9] B[7] VSS VSS VDD VDD OUT[151] sky130_fd_sc_hd__and2_0
x7[6] A[9] B[6] VSS VSS VDD VDD OUT[150] sky130_fd_sc_hd__and2_0
x7[5] A[9] B[5] VSS VSS VDD VDD OUT[149] sky130_fd_sc_hd__and2_0
x7[4] A[9] B[4] VSS VSS VDD VDD OUT[148] sky130_fd_sc_hd__and2_0
x7[3] A[9] B[3] VSS VSS VDD VDD OUT[147] sky130_fd_sc_hd__and2_0
x7[2] A[9] B[2] VSS VSS VDD VDD OUT[146] sky130_fd_sc_hd__and2_0
x7[1] A[9] B[1] VSS VSS VDD VDD OUT[145] sky130_fd_sc_hd__and2_0
x7[0] A[9] B[0] VSS VSS VDD VDD OUT[144] sky130_fd_sc_hd__and2_0
x8[15] A[8] B[15] VSS VSS VDD VDD OUT[143] sky130_fd_sc_hd__and2_0
x8[14] A[8] B[14] VSS VSS VDD VDD OUT[142] sky130_fd_sc_hd__and2_0
x8[13] A[8] B[13] VSS VSS VDD VDD OUT[141] sky130_fd_sc_hd__and2_0
x8[12] A[8] B[12] VSS VSS VDD VDD OUT[140] sky130_fd_sc_hd__and2_0
x8[11] A[8] B[11] VSS VSS VDD VDD OUT[139] sky130_fd_sc_hd__and2_0
x8[10] A[8] B[10] VSS VSS VDD VDD OUT[138] sky130_fd_sc_hd__and2_0
x8[9] A[8] B[9] VSS VSS VDD VDD OUT[137] sky130_fd_sc_hd__and2_0
x8[8] A[8] B[8] VSS VSS VDD VDD OUT[136] sky130_fd_sc_hd__and2_0
x8[7] A[8] B[7] VSS VSS VDD VDD OUT[135] sky130_fd_sc_hd__and2_0
x8[6] A[8] B[6] VSS VSS VDD VDD OUT[134] sky130_fd_sc_hd__and2_0
x8[5] A[8] B[5] VSS VSS VDD VDD OUT[133] sky130_fd_sc_hd__and2_0
x8[4] A[8] B[4] VSS VSS VDD VDD OUT[132] sky130_fd_sc_hd__and2_0
x8[3] A[8] B[3] VSS VSS VDD VDD OUT[131] sky130_fd_sc_hd__and2_0
x8[2] A[8] B[2] VSS VSS VDD VDD OUT[130] sky130_fd_sc_hd__and2_0
x8[1] A[8] B[1] VSS VSS VDD VDD OUT[129] sky130_fd_sc_hd__and2_0
x8[0] A[8] B[0] VSS VSS VDD VDD OUT[128] sky130_fd_sc_hd__and2_0
x9[15] A[7] B[15] VSS VSS VDD VDD OUT[127] sky130_fd_sc_hd__and2_0
x9[14] A[7] B[14] VSS VSS VDD VDD OUT[126] sky130_fd_sc_hd__and2_0
x9[13] A[7] B[13] VSS VSS VDD VDD OUT[125] sky130_fd_sc_hd__and2_0
x9[12] A[7] B[12] VSS VSS VDD VDD OUT[124] sky130_fd_sc_hd__and2_0
x9[11] A[7] B[11] VSS VSS VDD VDD OUT[123] sky130_fd_sc_hd__and2_0
x9[10] A[7] B[10] VSS VSS VDD VDD OUT[122] sky130_fd_sc_hd__and2_0
x9[9] A[7] B[9] VSS VSS VDD VDD OUT[121] sky130_fd_sc_hd__and2_0
x9[8] A[7] B[8] VSS VSS VDD VDD OUT[120] sky130_fd_sc_hd__and2_0
x9[7] A[7] B[7] VSS VSS VDD VDD OUT[119] sky130_fd_sc_hd__and2_0
x9[6] A[7] B[6] VSS VSS VDD VDD OUT[118] sky130_fd_sc_hd__and2_0
x9[5] A[7] B[5] VSS VSS VDD VDD OUT[117] sky130_fd_sc_hd__and2_0
x9[4] A[7] B[4] VSS VSS VDD VDD OUT[116] sky130_fd_sc_hd__and2_0
x9[3] A[7] B[3] VSS VSS VDD VDD OUT[115] sky130_fd_sc_hd__and2_0
x9[2] A[7] B[2] VSS VSS VDD VDD OUT[114] sky130_fd_sc_hd__and2_0
x9[1] A[7] B[1] VSS VSS VDD VDD OUT[113] sky130_fd_sc_hd__and2_0
x9[0] A[7] B[0] VSS VSS VDD VDD OUT[112] sky130_fd_sc_hd__and2_0
x10[15] A[6] B[15] VSS VSS VDD VDD OUT[111] sky130_fd_sc_hd__and2_0
x10[14] A[6] B[14] VSS VSS VDD VDD OUT[110] sky130_fd_sc_hd__and2_0
x10[13] A[6] B[13] VSS VSS VDD VDD OUT[109] sky130_fd_sc_hd__and2_0
x10[12] A[6] B[12] VSS VSS VDD VDD OUT[108] sky130_fd_sc_hd__and2_0
x10[11] A[6] B[11] VSS VSS VDD VDD OUT[107] sky130_fd_sc_hd__and2_0
x10[10] A[6] B[10] VSS VSS VDD VDD OUT[106] sky130_fd_sc_hd__and2_0
x10[9] A[6] B[9] VSS VSS VDD VDD OUT[105] sky130_fd_sc_hd__and2_0
x10[8] A[6] B[8] VSS VSS VDD VDD OUT[104] sky130_fd_sc_hd__and2_0
x10[7] A[6] B[7] VSS VSS VDD VDD OUT[103] sky130_fd_sc_hd__and2_0
x10[6] A[6] B[6] VSS VSS VDD VDD OUT[102] sky130_fd_sc_hd__and2_0
x10[5] A[6] B[5] VSS VSS VDD VDD OUT[101] sky130_fd_sc_hd__and2_0
x10[4] A[6] B[4] VSS VSS VDD VDD OUT[100] sky130_fd_sc_hd__and2_0
x10[3] A[6] B[3] VSS VSS VDD VDD OUT[99] sky130_fd_sc_hd__and2_0
x10[2] A[6] B[2] VSS VSS VDD VDD OUT[98] sky130_fd_sc_hd__and2_0
x10[1] A[6] B[1] VSS VSS VDD VDD OUT[97] sky130_fd_sc_hd__and2_0
x10[0] A[6] B[0] VSS VSS VDD VDD OUT[96] sky130_fd_sc_hd__and2_0
x11[15] A[5] B[15] VSS VSS VDD VDD OUT[95] sky130_fd_sc_hd__and2_0
x11[14] A[5] B[14] VSS VSS VDD VDD OUT[94] sky130_fd_sc_hd__and2_0
x11[13] A[5] B[13] VSS VSS VDD VDD OUT[93] sky130_fd_sc_hd__and2_0
x11[12] A[5] B[12] VSS VSS VDD VDD OUT[92] sky130_fd_sc_hd__and2_0
x11[11] A[5] B[11] VSS VSS VDD VDD OUT[91] sky130_fd_sc_hd__and2_0
x11[10] A[5] B[10] VSS VSS VDD VDD OUT[90] sky130_fd_sc_hd__and2_0
x11[9] A[5] B[9] VSS VSS VDD VDD OUT[89] sky130_fd_sc_hd__and2_0
x11[8] A[5] B[8] VSS VSS VDD VDD OUT[88] sky130_fd_sc_hd__and2_0
x11[7] A[5] B[7] VSS VSS VDD VDD OUT[87] sky130_fd_sc_hd__and2_0
x11[6] A[5] B[6] VSS VSS VDD VDD OUT[86] sky130_fd_sc_hd__and2_0
x11[5] A[5] B[5] VSS VSS VDD VDD OUT[85] sky130_fd_sc_hd__and2_0
x11[4] A[5] B[4] VSS VSS VDD VDD OUT[84] sky130_fd_sc_hd__and2_0
x11[3] A[5] B[3] VSS VSS VDD VDD OUT[83] sky130_fd_sc_hd__and2_0
x11[2] A[5] B[2] VSS VSS VDD VDD OUT[82] sky130_fd_sc_hd__and2_0
x11[1] A[5] B[1] VSS VSS VDD VDD OUT[81] sky130_fd_sc_hd__and2_0
x11[0] A[5] B[0] VSS VSS VDD VDD OUT[80] sky130_fd_sc_hd__and2_0
x12[15] A[4] B[15] VSS VSS VDD VDD OUT[79] sky130_fd_sc_hd__and2_0
x12[14] A[4] B[14] VSS VSS VDD VDD OUT[78] sky130_fd_sc_hd__and2_0
x12[13] A[4] B[13] VSS VSS VDD VDD OUT[77] sky130_fd_sc_hd__and2_0
x12[12] A[4] B[12] VSS VSS VDD VDD OUT[76] sky130_fd_sc_hd__and2_0
x12[11] A[4] B[11] VSS VSS VDD VDD OUT[75] sky130_fd_sc_hd__and2_0
x12[10] A[4] B[10] VSS VSS VDD VDD OUT[74] sky130_fd_sc_hd__and2_0
x12[9] A[4] B[9] VSS VSS VDD VDD OUT[73] sky130_fd_sc_hd__and2_0
x12[8] A[4] B[8] VSS VSS VDD VDD OUT[72] sky130_fd_sc_hd__and2_0
x12[7] A[4] B[7] VSS VSS VDD VDD OUT[71] sky130_fd_sc_hd__and2_0
x12[6] A[4] B[6] VSS VSS VDD VDD OUT[70] sky130_fd_sc_hd__and2_0
x12[5] A[4] B[5] VSS VSS VDD VDD OUT[69] sky130_fd_sc_hd__and2_0
x12[4] A[4] B[4] VSS VSS VDD VDD OUT[68] sky130_fd_sc_hd__and2_0
x12[3] A[4] B[3] VSS VSS VDD VDD OUT[67] sky130_fd_sc_hd__and2_0
x12[2] A[4] B[2] VSS VSS VDD VDD OUT[66] sky130_fd_sc_hd__and2_0
x12[1] A[4] B[1] VSS VSS VDD VDD OUT[65] sky130_fd_sc_hd__and2_0
x12[0] A[4] B[0] VSS VSS VDD VDD OUT[64] sky130_fd_sc_hd__and2_0
x13[15] A[3] B[15] VSS VSS VDD VDD OUT[63] sky130_fd_sc_hd__and2_0
x13[14] A[3] B[14] VSS VSS VDD VDD OUT[62] sky130_fd_sc_hd__and2_0
x13[13] A[3] B[13] VSS VSS VDD VDD OUT[61] sky130_fd_sc_hd__and2_0
x13[12] A[3] B[12] VSS VSS VDD VDD OUT[60] sky130_fd_sc_hd__and2_0
x13[11] A[3] B[11] VSS VSS VDD VDD OUT[59] sky130_fd_sc_hd__and2_0
x13[10] A[3] B[10] VSS VSS VDD VDD OUT[58] sky130_fd_sc_hd__and2_0
x13[9] A[3] B[9] VSS VSS VDD VDD OUT[57] sky130_fd_sc_hd__and2_0
x13[8] A[3] B[8] VSS VSS VDD VDD OUT[56] sky130_fd_sc_hd__and2_0
x13[7] A[3] B[7] VSS VSS VDD VDD OUT[55] sky130_fd_sc_hd__and2_0
x13[6] A[3] B[6] VSS VSS VDD VDD OUT[54] sky130_fd_sc_hd__and2_0
x13[5] A[3] B[5] VSS VSS VDD VDD OUT[53] sky130_fd_sc_hd__and2_0
x13[4] A[3] B[4] VSS VSS VDD VDD OUT[52] sky130_fd_sc_hd__and2_0
x13[3] A[3] B[3] VSS VSS VDD VDD OUT[51] sky130_fd_sc_hd__and2_0
x13[2] A[3] B[2] VSS VSS VDD VDD OUT[50] sky130_fd_sc_hd__and2_0
x13[1] A[3] B[1] VSS VSS VDD VDD OUT[49] sky130_fd_sc_hd__and2_0
x13[0] A[3] B[0] VSS VSS VDD VDD OUT[48] sky130_fd_sc_hd__and2_0
x14[15] A[2] B[15] VSS VSS VDD VDD OUT[47] sky130_fd_sc_hd__and2_0
x14[14] A[2] B[14] VSS VSS VDD VDD OUT[46] sky130_fd_sc_hd__and2_0
x14[13] A[2] B[13] VSS VSS VDD VDD OUT[45] sky130_fd_sc_hd__and2_0
x14[12] A[2] B[12] VSS VSS VDD VDD OUT[44] sky130_fd_sc_hd__and2_0
x14[11] A[2] B[11] VSS VSS VDD VDD OUT[43] sky130_fd_sc_hd__and2_0
x14[10] A[2] B[10] VSS VSS VDD VDD OUT[42] sky130_fd_sc_hd__and2_0
x14[9] A[2] B[9] VSS VSS VDD VDD OUT[41] sky130_fd_sc_hd__and2_0
x14[8] A[2] B[8] VSS VSS VDD VDD OUT[40] sky130_fd_sc_hd__and2_0
x14[7] A[2] B[7] VSS VSS VDD VDD OUT[39] sky130_fd_sc_hd__and2_0
x14[6] A[2] B[6] VSS VSS VDD VDD OUT[38] sky130_fd_sc_hd__and2_0
x14[5] A[2] B[5] VSS VSS VDD VDD OUT[37] sky130_fd_sc_hd__and2_0
x14[4] A[2] B[4] VSS VSS VDD VDD OUT[36] sky130_fd_sc_hd__and2_0
x14[3] A[2] B[3] VSS VSS VDD VDD OUT[35] sky130_fd_sc_hd__and2_0
x14[2] A[2] B[2] VSS VSS VDD VDD OUT[34] sky130_fd_sc_hd__and2_0
x14[1] A[2] B[1] VSS VSS VDD VDD OUT[33] sky130_fd_sc_hd__and2_0
x14[0] A[2] B[0] VSS VSS VDD VDD OUT[32] sky130_fd_sc_hd__and2_0
x15[15] A[1] B[15] VSS VSS VDD VDD OUT[31] sky130_fd_sc_hd__and2_0
x15[14] A[1] B[14] VSS VSS VDD VDD OUT[30] sky130_fd_sc_hd__and2_0
x15[13] A[1] B[13] VSS VSS VDD VDD OUT[29] sky130_fd_sc_hd__and2_0
x15[12] A[1] B[12] VSS VSS VDD VDD OUT[28] sky130_fd_sc_hd__and2_0
x15[11] A[1] B[11] VSS VSS VDD VDD OUT[27] sky130_fd_sc_hd__and2_0
x15[10] A[1] B[10] VSS VSS VDD VDD OUT[26] sky130_fd_sc_hd__and2_0
x15[9] A[1] B[9] VSS VSS VDD VDD OUT[25] sky130_fd_sc_hd__and2_0
x15[8] A[1] B[8] VSS VSS VDD VDD OUT[24] sky130_fd_sc_hd__and2_0
x15[7] A[1] B[7] VSS VSS VDD VDD OUT[23] sky130_fd_sc_hd__and2_0
x15[6] A[1] B[6] VSS VSS VDD VDD OUT[22] sky130_fd_sc_hd__and2_0
x15[5] A[1] B[5] VSS VSS VDD VDD OUT[21] sky130_fd_sc_hd__and2_0
x15[4] A[1] B[4] VSS VSS VDD VDD OUT[20] sky130_fd_sc_hd__and2_0
x15[3] A[1] B[3] VSS VSS VDD VDD OUT[19] sky130_fd_sc_hd__and2_0
x15[2] A[1] B[2] VSS VSS VDD VDD OUT[18] sky130_fd_sc_hd__and2_0
x15[1] A[1] B[1] VSS VSS VDD VDD OUT[17] sky130_fd_sc_hd__and2_0
x15[0] A[1] B[0] VSS VSS VDD VDD OUT[16] sky130_fd_sc_hd__and2_0
x16[15] A[0] B[15] VSS VSS VDD VDD OUT[15] sky130_fd_sc_hd__and2_0
x16[14] A[0] B[14] VSS VSS VDD VDD OUT[14] sky130_fd_sc_hd__and2_0
x16[13] A[0] B[13] VSS VSS VDD VDD OUT[13] sky130_fd_sc_hd__and2_0
x16[12] A[0] B[12] VSS VSS VDD VDD OUT[12] sky130_fd_sc_hd__and2_0
x16[11] A[0] B[11] VSS VSS VDD VDD OUT[11] sky130_fd_sc_hd__and2_0
x16[10] A[0] B[10] VSS VSS VDD VDD OUT[10] sky130_fd_sc_hd__and2_0
x16[9] A[0] B[9] VSS VSS VDD VDD OUT[9] sky130_fd_sc_hd__and2_0
x16[8] A[0] B[8] VSS VSS VDD VDD OUT[8] sky130_fd_sc_hd__and2_0
x16[7] A[0] B[7] VSS VSS VDD VDD OUT[7] sky130_fd_sc_hd__and2_0
x16[6] A[0] B[6] VSS VSS VDD VDD OUT[6] sky130_fd_sc_hd__and2_0
x16[5] A[0] B[5] VSS VSS VDD VDD OUT[5] sky130_fd_sc_hd__and2_0
x16[4] A[0] B[4] VSS VSS VDD VDD OUT[4] sky130_fd_sc_hd__and2_0
x16[3] A[0] B[3] VSS VSS VDD VDD OUT[3] sky130_fd_sc_hd__and2_0
x16[2] A[0] B[2] VSS VSS VDD VDD OUT[2] sky130_fd_sc_hd__and2_0
x16[1] A[0] B[1] VSS VSS VDD VDD OUT[1] sky130_fd_sc_hd__and2_0
x16[0] A[0] B[0] VSS VSS VDD VDD OUT[0] sky130_fd_sc_hd__and2_0
.ends


* expanding   symbol:  WL_Interface/WL_driver.sym # of pins=14
** sym_path: WL_Interface/WL_driver.sym
** sch_path: WL_Interface/WL_driver.sch
.subckt WL_driver SELECT AVSS VWL_SET VSS VWL_RST SET_FORM SET_RST VDD VWL_READ VWL_FORM WE AVDD VWL
+ EN
*.ipin AVSS
*.ipin VSS
*.ipin VDD
*.ipin AVDD
*.ipin SELECT
*.ipin SET_FORM
*.ipin SET_RST
*.ipin WE
*.ipin EN
*.iopin VWL_SET
*.iopin VWL_RST
*.iopin VWL_READ
*.iopin VWL_FORM
*.iopin VWL
x1 SET_FORM SET_RST A VSS VSS VDD VDD WL_SET_EN_BAR sky130_fd_sc_hd__nand3b_1
x2 SET_RST A VSS VSS VDD VDD WL_RESET_EN_BAR sky130_fd_sc_hd__nand2b_1
x3 A SET_RST SET_FORM VSS VSS VDD VDD WL_FORM_EN_BAR sky130_fd_sc_hd__nand3_1
x4 WE EN SELECT VSS VSS VDD VDD WL_READ_EN_BAR sky130_fd_sc_hd__nand3b_1
x5 WE SELECT EN VSS VSS VDD VDD A sky130_fd_sc_hd__and3_1
x6 EN SELECT VSS VSS VDD VDD SEL_BAR sky130_fd_sc_hd__nand2_1
XM1 VWL SET_EN_BAR VWL_SET AVDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=7.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 VWL_SET SET_EN VWL AVSS sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=7.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM3 VWL RST_EN_BAR VWL_SET AVDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=7.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 VWL FORM_EN_BAR VWL_FORM AVDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=7.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM5 VWL SEL_BAR AVSS AVSS sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=10.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
x7 AVDD SET_EN SET_EN_BAR VDD WL_SET_EN_BAR VSS lvl_shifter_1p8_to_5
x8 AVDD net1 RST_EN_BAR VDD WL_RESET_EN_BAR VSS lvl_shifter_1p8_to_5
x9 AVDD net2 FORM_EN_BAR VDD WL_FORM_EN_BAR VSS lvl_shifter_1p8_to_5
x10 AVDD net3 READ_EN_BAR VDD WL_READ_EN_BAR VSS lvl_shifter_1p8_to_5
* noconn #net1
* noconn #net2
* noconn #net3
XM6 VWL READ_EN_BAR VWL_READ AVDD sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=7.0 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends


* expanding   symbol:  BL_SL_Writing_Interface/lvl_shifter_1p8_to_5.sym # of pins=6
** sym_path: BL_SL_Writing_Interface/lvl_shifter_1p8_to_5.sym
** sch_path: BL_SL_Writing_Interface/lvl_shifter_1p8_to_5.sch
.subckt lvl_shifter_1p8_to_5 VDD_HI OUTB OUT VDD_LO IN VSS
*.ipin VDD_HI
*.opin OUT
*.opin OUTB
*.ipin IN
*.ipin VDD_LO
*.ipin VSS
XM5 net1 IN VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM7 net2 net1 VSS VSS sky130_fd_pr__nfet_01v8 L=0.15 W=0.42 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM3 net1 IN VDD_LO VDD_LO sky130_fd_pr__pfet_01v8 L=0.15 W=0.84 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM4 net2 net1 VDD_LO VDD_LO sky130_fd_pr__pfet_01v8 L=0.15 W=0.84 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM6 OUT net1 VSS VSS sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM8 OUTB net2 VSS VSS sky130_fd_pr__nfet_g5v0d10v5 L=0.5 W=5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29' as='int((nf+2)/2) * W/nf * 0.29'
+ pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)' nrd='0.29 / W' nrs='0.29 / W'
+ sa=0 sb=0 sd=0 mult=1 m=1
XM1 OUT OUTB VDD_HI VDD_HI sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=1.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
XM2 OUTB OUT VDD_HI VDD_HI sky130_fd_pr__pfet_g5v0d10v5 L=0.5 W=1.5 nf=1 ad='int((nf+1)/2) * W/nf * 0.29'
+ as='int((nf+2)/2) * W/nf * 0.29' pd='2*int((nf+1)/2) * (W/nf + 0.29)' ps='2*int((nf+2)/2) * (W/nf + 0.29)'
+ nrd='0.29 / W' nrs='0.29 / W' sa=0 sb=0 sd=0 mult=1 m=1
.ends

.end
