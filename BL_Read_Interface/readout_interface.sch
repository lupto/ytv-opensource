** sch_path: BL_Read_Interface/readout_interface.sch
**.subckt readout_interface VBL_READ AVDD AVSS VDD VSA VSS
*+ DI[15],DI[14],DI[13],DI[12],DI[11],DI[10],DI[9],DI[8],DI[7],DI[6],DI[5],DI[4],DI[3],DI[2],DI[1],DI[0] ARRAY_EN
*+ COL_ADDR[7],COL_ADDR[6],COL_ADDR[5],COL_ADDR[4],COL_ADDR[3],COL_ADDR[2],COL_ADDR[1],COL_ADDR[0] WE
*+ BL[2303],BL[2302],BL[2301],BL[2300],BL[2299],BL[2298],BL[2297],BL[2296],BL[2295],BL[2294],BL[2293],BL[2292],BL[2291],BL[2290],BL[2289],BL[2288],BL[2287],BL[2286],BL[2285],BL[2284],BL[2283],BL[2282],BL[2281],BL[2280],BL[2279],BL[2278],BL[2277],BL[2276],BL[2275],BL[2274],BL[2273],BL[2272],BL[2271],BL[2270],BL[2269],BL[2268],BL[2267],BL[2266],BL[2265],BL[2264],BL[2263],BL[2262],BL[2261],BL[2260],BL[2259],BL[2258],BL[2257],BL[2256],BL[2255],BL[2254],BL[2253],BL[2252],BL[2251],BL[2250],BL[2249],BL[2248],BL[2247],BL[2246],BL[2245],BL[2244],BL[2243],BL[2242],BL[2241],BL[2240],BL[2239],BL[2238],BL[2237],BL[2236],BL[2235],BL[2234],BL[2233],BL[2232],BL[2231],BL[2230],BL[2229],BL[2228],BL[2227],BL[2226],BL[2225],BL[2224],BL[2223],BL[2222],BL[2221],BL[2220],BL[2219],BL[2218],BL[2217],BL[2216],BL[2215],BL[2214],BL[2213],BL[2212],BL[2211],BL[2210],BL[2209],BL[2208],BL[2207],BL[2206],BL[2205],BL[2204],BL[2203],BL[2202],BL[2201],BL[2200],BL[2199],BL[2198],BL[2197],BL[2196],BL[2195],BL[2194],BL[2193],BL[2192],BL[2191],BL[2190],BL[2189],BL[2188],BL[2187],BL[2186],BL[2185],BL[2184],BL[2183],BL[2182],BL[2181],BL[2180],BL[2179],BL[2178],BL[2177],BL[2176],BL[2175],BL[2174],BL[2173],BL[2172],BL[2171],BL[2170],BL[2169],BL[2168],BL[2167],BL[2166],BL[2165],BL[2164],BL[2163],BL[2162],BL[2161],BL[2160],BL[2159],BL[2158],BL[2157],BL[2156],BL[2155],BL[2154],BL[2153],BL[2152],BL[2151],BL[2150],BL[2149],BL[2148],BL[2147],BL[2146],BL[2145],BL[2144],BL[2143],BL[2142],BL[2141],BL[2140],BL[2139],BL[2138],BL[2137],BL[2136],BL[2135],BL[2134],BL[2133],BL[2132],BL[2131],BL[2130],BL[2129],BL[2128],BL[2127],BL[2126],BL[2125],BL[2124],BL[2123],BL[2122],BL[2121],BL[2120],BL[2119],BL[2118],BL[2117],BL[2116],BL[2115],BL[2114],BL[2113],BL[2112],BL[2111],BL[2110],BL[2109],BL[2108],BL[2107],BL[2106],BL[2105],BL[2104],BL[2103],BL[2102],BL[2101],BL[2100],BL[2099],BL[2098],BL[2097],BL[2096],BL[2095],BL[2094],BL[2093],BL[2092],BL[2091],BL[2090],BL[2089],BL[2088],BL[2087],BL[2086],BL[2085],BL[2084],BL[2083],BL[2082],BL[2081],BL[2080],BL[2079],BL[2078],BL[2077],BL[2076],BL[2075],BL[2074],BL[2073],BL[2072],BL[2071],BL[2070],BL[2069],BL[2068],BL[2067],BL[2066],BL[2065],BL[2064],BL[2063],BL[2062],BL[2061],BL[2060],BL[2059],BL[2058],BL[2057],BL[2056],BL[2055],BL[2054],BL[2053],BL[2052],BL[2051],BL[2050],BL[2049],BL[2048],BL[2047],BL[2046],BL[2045],BL[2044],BL[2043],BL[2042],BL[2041],BL[2040],BL[2039],BL[2038],BL[2037],BL[2036],BL[2035],BL[2034],BL[2033],BL[2032],BL[2031],BL[2030],BL[2029],BL[2028],BL[2027],BL[2026],BL[2025],BL[2024],BL[2023],BL[2022],BL[2021],BL[2020],BL[2019],BL[2018],BL[2017],BL[2016],BL[2015],BL[2014],BL[2013],BL[2012],BL[2011],BL[2010],BL[2009],BL[2008],BL[2007],BL[2006],BL[2005],BL[2004],BL[2003],BL[2002],BL[2001],BL[2000],BL[1999],BL[1998],BL[1997],BL[1996],BL[1995],BL[1994],BL[1993],BL[1992],BL[1991],BL[1990],BL[1989],BL[1988],BL[1987],BL[1986],BL[1985],BL[1984],BL[1983],BL[1982],BL[1981],BL[1980],BL[1979],BL[1978],BL[1977],BL[1976],BL[1975],BL[1974],BL[1973],BL[1972],BL[1971],BL[1970],BL[1969],BL[1968],BL[1967],BL[1966],BL[1965],BL[1964],BL[1963],BL[1962],BL[1961],BL[1960],BL[1959],BL[1958],BL[1957],BL[1956],BL[1955],BL[1954],BL[1953],BL[1952],BL[1951],BL[1950],BL[1949],BL[1948],BL[1947],BL[1946],BL[1945],BL[1944],BL[1943],BL[1942],BL[1941],BL[1940],BL[1939],BL[1938],BL[1937],BL[1936],BL[1935],BL[1934],BL[1933],BL[1932],BL[1931],BL[1930],BL[1929],BL[1928],BL[1927],BL[1926],BL[1925],BL[1924],BL[1923],BL[1922],BL[1921],BL[1920],BL[1919],BL[1918],BL[1917],BL[1916],BL[1915],BL[1914],BL[1913],BL[1912],BL[1911],BL[1910],BL[1909],BL[1908],BL[1907],BL[1906],BL[1905],BL[1904],BL[1903],BL[1902],BL[1901],BL[1900],BL[1899],BL[1898],BL[1897],BL[1896],BL[1895],BL[1894],BL[1893],BL[1892],BL[1891],BL[1890],BL[1889],BL[1888],BL[1887],BL[1886],BL[1885],BL[1884],BL[1883],BL[1882],BL[1881],BL[1880],BL[1879],BL[1878],BL[1877],BL[1876],BL[1875],BL[1874],BL[1873],BL[1872],BL[1871],BL[1870],BL[1869],BL[1868],BL[1867],BL[1866],BL[1865],BL[1864],BL[1863],BL[1862],BL[1861],BL[1860],BL[1859],BL[1858],BL[1857],BL[1856],BL[1855],BL[1854],BL[1853],BL[1852],BL[1851],BL[1850],BL[1849],BL[1848],BL[1847],BL[1846],BL[1845],BL[1844],BL[1843],BL[1842],BL[1841],BL[1840],BL[1839],BL[1838],BL[1837],BL[1836],BL[1835],BL[1834],BL[1833],BL[1832],BL[1831],BL[1830],BL[1829],BL[1828],BL[1827],BL[1826],BL[1825],BL[1824],BL[1823],BL[1822],BL[1821],BL[1820],BL[1819],BL[1818],BL[1817],BL[1816],BL[1815],BL[1814],BL[1813],BL[1812],BL[1811],BL[1810],BL[1809],BL[1808],BL[1807],BL[1806],BL[1805],BL[1804],BL[1803],BL[1802],BL[1801],BL[1800],BL[1799],BL[1798],BL[1797],BL[1796],BL[1795],BL[1794],BL[1793],BL[1792],BL[1791],BL[1790],BL[1789],BL[1788],BL[1787],BL[1786],BL[1785],BL[1784],BL[1783],BL[1782],BL[1781],BL[1780],BL[1779],BL[1778],BL[1777],BL[1776],BL[1775],BL[1774],BL[1773],BL[1772],BL[1771],BL[1770],BL[1769],BL[1768],BL[1767],BL[1766],BL[1765],BL[1764],BL[1763],BL[1762],BL[1761],BL[1760],BL[1759],BL[1758],BL[1757],BL[1756],BL[1755],BL[1754],BL[1753],BL[1752],BL[1751],BL[1750],BL[1749],BL[1748],BL[1747],BL[1746],BL[1745],BL[1744],BL[1743],BL[1742],BL[1741],BL[1740],BL[1739],BL[1738],BL[1737],BL[1736],BL[1735],BL[1734],BL[1733],BL[1732],BL[1731],BL[1730],BL[1729],BL[1728],BL[1727],BL[1726],BL[1725],BL[1724],BL[1723],BL[1722],BL[1721],BL[1720],BL[1719],BL[1718],BL[1717],BL[1716],BL[1715],BL[1714],BL[1713],BL[1712],BL[1711],BL[1710],BL[1709],BL[1708],BL[1707],BL[1706],BL[1705],BL[1704],BL[1703],BL[1702],BL[1701],BL[1700],BL[1699],BL[1698],BL[1697],BL[1696],BL[1695],BL[1694],BL[1693],BL[1692],BL[1691],BL[1690],BL[1689],BL[1688],BL[1687],BL[1686],BL[1685],BL[1684],BL[1683],BL[1682],BL[1681],BL[1680],BL[1679],BL[1678],BL[1677],BL[1676],BL[1675],BL[1674],BL[1673],BL[1672],BL[1671],BL[1670],BL[1669],BL[1668],BL[1667],BL[1666],BL[1665],BL[1664],BL[1663],BL[1662],BL[1661],BL[1660],BL[1659],BL[1658],BL[1657],BL[1656],BL[1655],BL[1654],BL[1653],BL[1652],BL[1651],BL[1650],BL[1649],BL[1648],BL[1647],BL[1646],BL[1645],BL[1644],BL[1643],BL[1642],BL[1641],BL[1640],BL[1639],BL[1638],BL[1637],BL[1636],BL[1635],BL[1634],BL[1633],BL[1632],BL[1631],BL[1630],BL[1629],BL[1628],BL[1627],BL[1626],BL[1625],BL[1624],BL[1623],BL[1622],BL[1621],BL[1620],BL[1619],BL[1618],BL[1617],BL[1616],BL[1615],BL[1614],BL[1613],BL[1612],BL[1611],BL[1610],BL[1609],BL[1608],BL[1607],BL[1606],BL[1605],BL[1604],BL[1603],BL[1602],BL[1601],BL[1600],BL[1599],BL[1598],BL[1597],BL[1596],BL[1595],BL[1594],BL[1593],BL[1592],BL[1591],BL[1590],BL[1589],BL[1588],BL[1587],BL[1586],BL[1585],BL[1584],BL[1583],BL[1582],BL[1581],BL[1580],BL[1579],BL[1578],BL[1577],BL[1576],BL[1575],BL[1574],BL[1573],BL[1572],BL[1571],BL[1570],BL[1569],BL[1568],BL[1567],BL[1566],BL[1565],BL[1564],BL[1563],BL[1562],BL[1561],BL[1560],BL[1559],BL[1558],BL[1557],BL[1556],BL[1555],BL[1554],BL[1553],BL[1552],BL[1551],BL[1550],BL[1549],BL[1548],BL[1547],BL[1546],BL[1545],BL[1544],BL[1543],BL[1542],BL[1541],BL[1540],BL[1539],BL[1538],BL[1537],BL[1536],BL[1535],BL[1534],BL[1533],BL[1532],BL[1531],BL[1530],BL[1529],BL[1528],BL[1527],BL[1526],BL[1525],BL[1524],BL[1523],BL[1522],BL[1521],BL[1520],BL[1519],BL[1518],BL[1517],BL[1516],BL[1515],BL[1514],BL[1513],BL[1512],BL[1511],BL[1510],BL[1509],BL[1508],BL[1507],BL[1506],BL[1505],BL[1504],BL[1503],BL[1502],BL[1501],BL[1500],BL[1499],BL[1498],BL[1497],BL[1496],BL[1495],BL[1494],BL[1493],BL[1492],BL[1491],BL[1490],BL[1489],BL[1488],BL[1487],BL[1486],BL[1485],BL[1484],BL[1483],BL[1482],BL[1481],BL[1480],BL[1479],BL[1478],BL[1477],BL[1476],BL[1475],BL[1474],BL[1473],BL[1472],BL[1471],BL[1470],BL[1469],BL[1468],BL[1467],BL[1466],BL[1465],BL[1464],BL[1463],BL[1462],BL[1461],BL[1460],BL[1459],BL[1458],BL[1457],BL[1456],BL[1455],BL[1454],BL[1453],BL[1452],BL[1451],BL[1450],BL[1449],BL[1448],BL[1447],BL[1446],BL[1445],BL[1444],BL[1443],BL[1442],BL[1441],BL[1440],BL[1439],BL[1438],BL[1437],BL[1436],BL[1435],BL[1434],BL[1433],BL[1432],BL[1431],BL[1430],BL[1429],BL[1428],BL[1427],BL[1426],BL[1425],BL[1424],BL[1423],BL[1422],BL[1421],BL[1420],BL[1419],BL[1418],BL[1417],BL[1416],BL[1415],BL[1414],BL[1413],BL[1412],BL[1411],BL[1410],BL[1409],BL[1408],BL[1407],BL[1406],BL[1405],BL[1404],BL[1403],BL[1402],BL[1401],BL[1400],BL[1399],BL[1398],BL[1397],BL[1396],BL[1395],BL[1394],BL[1393],BL[1392],BL[1391],BL[1390],BL[1389],BL[1388],BL[1387],BL[1386],BL[1385],BL[1384],BL[1383],BL[1382],BL[1381],BL[1380],BL[1379],BL[1378],BL[1377],BL[1376],BL[1375],BL[1374],BL[1373],BL[1372],BL[1371],BL[1370],BL[1369],BL[1368],BL[1367],BL[1366],BL[1365],BL[1364],BL[1363],BL[1362],BL[1361],BL[1360],BL[1359],BL[1358],BL[1357],BL[1356],BL[1355],BL[1354],BL[1353],BL[1352],BL[1351],BL[1350],BL[1349],BL[1348],BL[1347],BL[1346],BL[1345],BL[1344],BL[1343],BL[1342],BL[1341],BL[1340],BL[1339],BL[1338],BL[1337],BL[1336],BL[1335],BL[1334],BL[1333],BL[1332],BL[1331],BL[1330],BL[1329],BL[1328],BL[1327],BL[1326],BL[1325],BL[1324],BL[1323],BL[1322],BL[1321],BL[1320],BL[1319],BL[1318],BL[1317],BL[1316],BL[1315],BL[1314],BL[1313],BL[1312],BL[1311],BL[1310],BL[1309],BL[1308],BL[1307],BL[1306],BL[1305],BL[1304],BL[1303],BL[1302],BL[1301],BL[1300],BL[1299],BL[1298],BL[1297],BL[1296],BL[1295],BL[1294],BL[1293],BL[1292],BL[1291],BL[1290],BL[1289],BL[1288],BL[1287],BL[1286],BL[1285],BL[1284],BL[1283],BL[1282],BL[1281],BL[1280],BL[1279],BL[1278],BL[1277],BL[1276],BL[1275],BL[1274],BL[1273],BL[1272],BL[1271],BL[1270],BL[1269],BL[1268],BL[1267],BL[1266],BL[1265],BL[1264],BL[1263],BL[1262],BL[1261],BL[1260],BL[1259],BL[1258],BL[1257],BL[1256],BL[1255],BL[1254],BL[1253],BL[1252],BL[1251],BL[1250],BL[1249],BL[1248],BL[1247],BL[1246],BL[1245],BL[1244],BL[1243],BL[1242],BL[1241],BL[1240],BL[1239],BL[1238],BL[1237],BL[1236],BL[1235],BL[1234],BL[1233],BL[1232],BL[1231],BL[1230],BL[1229],BL[1228],BL[1227],BL[1226],BL[1225],BL[1224],BL[1223],BL[1222],BL[1221],BL[1220],BL[1219],BL[1218],BL[1217],BL[1216],BL[1215],BL[1214],BL[1213],BL[1212],BL[1211],BL[1210],BL[1209],BL[1208],BL[1207],BL[1206],BL[1205],BL[1204],BL[1203],BL[1202],BL[1201],BL[1200],BL[1199],BL[1198],BL[1197],BL[1196],BL[1195],BL[1194],BL[1193],BL[1192],BL[1191],BL[1190],BL[1189],BL[1188],BL[1187],BL[1186],BL[1185],BL[1184],BL[1183],BL[1182],BL[1181],BL[1180],BL[1179],BL[1178],BL[1177],BL[1176],BL[1175],BL[1174],BL[1173],BL[1172],BL[1171],BL[1170],BL[1169],BL[1168],BL[1167],BL[1166],BL[1165],BL[1164],BL[1163],BL[1162],BL[1161],BL[1160],BL[1159],BL[1158],BL[1157],BL[1156],BL[1155],BL[1154],BL[1153],BL[1152],BL[1151],BL[1150],BL[1149],BL[1148],BL[1147],BL[1146],BL[1145],BL[1144],BL[1143],BL[1142],BL[1141],BL[1140],BL[1139],BL[1138],BL[1137],BL[1136],BL[1135],BL[1134],BL[1133],BL[1132],BL[1131],BL[1130],BL[1129],BL[1128],BL[1127],BL[1126],BL[1125],BL[1124],BL[1123],BL[1122],BL[1121],BL[1120],BL[1119],BL[1118],BL[1117],BL[1116],BL[1115],BL[1114],BL[1113],BL[1112],BL[1111],BL[1110],BL[1109],BL[1108],BL[1107],BL[1106],BL[1105],BL[1104],BL[1103],BL[1102],BL[1101],BL[1100],BL[1099],BL[1098],BL[1097],BL[1096],BL[1095],BL[1094],BL[1093],BL[1092],BL[1091],BL[1090],BL[1089],BL[1088],BL[1087],BL[1086],BL[1085],BL[1084],BL[1083],BL[1082],BL[1081],BL[1080],BL[1079],BL[1078],BL[1077],BL[1076],BL[1075],BL[1074],BL[1073],BL[1072],BL[1071],BL[1070],BL[1069],BL[1068],BL[1067],BL[1066],BL[1065],BL[1064],BL[1063],BL[1062],BL[1061],BL[1060],BL[1059],BL[1058],BL[1057],BL[1056],BL[1055],BL[1054],BL[1053],BL[1052],BL[1051],BL[1050],BL[1049],BL[1048],BL[1047],BL[1046],BL[1045],BL[1044],BL[1043],BL[1042],BL[1041],BL[1040],BL[1039],BL[1038],BL[1037],BL[1036],BL[1035],BL[1034],BL[1033],BL[1032],BL[1031],BL[1030],BL[1029],BL[1028],BL[1027],BL[1026],BL[1025],BL[1024],BL[1023],BL[1022],BL[1021],BL[1020],BL[1019],BL[1018],BL[1017],BL[1016],BL[1015],BL[1014],BL[1013],BL[1012],BL[1011],BL[1010],BL[1009],BL[1008],BL[1007],BL[1006],BL[1005],BL[1004],BL[1003],BL[1002],BL[1001],BL[1000],BL[999],BL[998],BL[997],BL[996],BL[995],BL[994],BL[993],BL[992],BL[991],BL[990],BL[989],BL[988],BL[987],BL[986],BL[985],BL[984],BL[983],BL[982],BL[981],BL[980],BL[979],BL[978],BL[977],BL[976],BL[975],BL[974],BL[973],BL[972],BL[971],BL[970],BL[969],BL[968],BL[967],BL[966],BL[965],BL[964],BL[963],BL[962],BL[961],BL[960],BL[959],BL[958],BL[957],BL[956],BL[955],BL[954],BL[953],BL[952],BL[951],BL[950],BL[949],BL[948],BL[947],BL[946],BL[945],BL[944],BL[943],BL[942],BL[941],BL[940],BL[939],BL[938],BL[937],BL[936],BL[935],BL[934],BL[933],BL[932],BL[931],BL[930],BL[929],BL[928],BL[927],BL[926],BL[925],BL[924],BL[923],BL[922],BL[921],BL[920],BL[919],BL[918],BL[917],BL[916],BL[915],BL[914],BL[913],BL[912],BL[911],BL[910],BL[909],BL[908],BL[907],BL[906],BL[905],BL[904],BL[903],BL[902],BL[901],BL[900],BL[899],BL[898],BL[897],BL[896],BL[895],BL[894],BL[893],BL[892],BL[891],BL[890],BL[889],BL[888],BL[887],BL[886],BL[885],BL[884],BL[883],BL[882],BL[881],BL[880],BL[879],BL[878],BL[877],BL[876],BL[875],BL[874],BL[873],BL[872],BL[871],BL[870],BL[869],BL[868],BL[867],BL[866],BL[865],BL[864],BL[863],BL[862],BL[861],BL[860],BL[859],BL[858],BL[857],BL[856],BL[855],BL[854],BL[853],BL[852],BL[851],BL[850],BL[849],BL[848],BL[847],BL[846],BL[845],BL[844],BL[843],BL[842],BL[841],BL[840],BL[839],BL[838],BL[837],BL[836],BL[835],BL[834],BL[833],BL[832],BL[831],BL[830],BL[829],BL[828],BL[827],BL[826],BL[825],BL[824],BL[823],BL[822],BL[821],BL[820],BL[819],BL[818],BL[817],BL[816],BL[815],BL[814],BL[813],BL[812],BL[811],BL[810],BL[809],BL[808],BL[807],BL[806],BL[805],BL[804],BL[803],BL[802],BL[801],BL[800],BL[799],BL[798],BL[797],BL[796],BL[795],BL[794],BL[793],BL[792],BL[791],BL[790],BL[789],BL[788],BL[787],BL[786],BL[785],BL[784],BL[783],BL[782],BL[781],BL[780],BL[779],BL[778],BL[777],BL[776],BL[775],BL[774],BL[773],BL[772],BL[771],BL[770],BL[769],BL[768],BL[767],BL[766],BL[765],BL[764],BL[763],BL[762],BL[761],BL[760],BL[759],BL[758],BL[757],BL[756],BL[755],BL[754],BL[753],BL[752],BL[751],BL[750],BL[749],BL[748],BL[747],BL[746],BL[745],BL[744],BL[743],BL[742],BL[741],BL[740],BL[739],BL[738],BL[737],BL[736],BL[735],BL[734],BL[733],BL[732],BL[731],BL[730],BL[729],BL[728],BL[727],BL[726],BL[725],BL[724],BL[723],BL[722],BL[721],BL[720],BL[719],BL[718],BL[717],BL[716],BL[715],BL[714],BL[713],BL[712],BL[711],BL[710],BL[709],BL[708],BL[707],BL[706],BL[705],BL[704],BL[703],BL[702],BL[701],BL[700],BL[699],BL[698],BL[697],BL[696],BL[695],BL[694],BL[693],BL[692],BL[691],BL[690],BL[689],BL[688],BL[687],BL[686],BL[685],BL[684],BL[683],BL[682],BL[681],BL[680],BL[679],BL[678],BL[677],BL[676],BL[675],BL[674],BL[673],BL[672],BL[671],BL[670],BL[669],BL[668],BL[667],BL[666],BL[665],BL[664],BL[663],BL[662],BL[661],BL[660],BL[659],BL[658],BL[657],BL[656],BL[655],BL[654],BL[653],BL[652],BL[651],BL[650],BL[649],BL[648],BL[647],BL[646],BL[645],BL[644],BL[643],BL[642],BL[641],BL[640],BL[639],BL[638],BL[637],BL[636],BL[635],BL[634],BL[633],BL[632],BL[631],BL[630],BL[629],BL[628],BL[627],BL[626],BL[625],BL[624],BL[623],BL[622],BL[621],BL[620],BL[619],BL[618],BL[617],BL[616],BL[615],BL[614],BL[613],BL[612],BL[611],BL[610],BL[609],BL[608],BL[607],BL[606],BL[605],BL[604],BL[603],BL[602],BL[601],BL[600],BL[599],BL[598],BL[597],BL[596],BL[595],BL[594],BL[593],BL[592],BL[591],BL[590],BL[589],BL[588],BL[587],BL[586],BL[585],BL[584],BL[583],BL[582],BL[581],BL[580],BL[579],BL[578],BL[577],BL[576],BL[575],BL[574],BL[573],BL[572],BL[571],BL[570],BL[569],BL[568],BL[567],BL[566],BL[565],BL[564],BL[563],BL[562],BL[561],BL[560],BL[559],BL[558],BL[557],BL[556],BL[555],BL[554],BL[553],BL[552],BL[551],BL[550],BL[549],BL[548],BL[547],BL[546],BL[545],BL[544],BL[543],BL[542],BL[541],BL[540],BL[539],BL[538],BL[537],BL[536],BL[535],BL[534],BL[533],BL[532],BL[531],BL[530],BL[529],BL[528],BL[527],BL[526],BL[525],BL[524],BL[523],BL[522],BL[521],BL[520],BL[519],BL[518],BL[517],BL[516],BL[515],BL[514],BL[513],BL[512],BL[511],BL[510],BL[509],BL[508],BL[507],BL[506],BL[505],BL[504],BL[503],BL[502],BL[501],BL[500],BL[499],BL[498],BL[497],BL[496],BL[495],BL[494],BL[493],BL[492],BL[491],BL[490],BL[489],BL[488],BL[487],BL[486],BL[485],BL[484],BL[483],BL[482],BL[481],BL[480],BL[479],BL[478],BL[477],BL[476],BL[475],BL[474],BL[473],BL[472],BL[471],BL[470],BL[469],BL[468],BL[467],BL[466],BL[465],BL[464],BL[463],BL[462],BL[461],BL[460],BL[459],BL[458],BL[457],BL[456],BL[455],BL[454],BL[453],BL[452],BL[451],BL[450],BL[449],BL[448],BL[447],BL[446],BL[445],BL[444],BL[443],BL[442],BL[441],BL[440],BL[439],BL[438],BL[437],BL[436],BL[435],BL[434],BL[433],BL[432],BL[431],BL[430],BL[429],BL[428],BL[427],BL[426],BL[425],BL[424],BL[423],BL[422],BL[421],BL[420],BL[419],BL[418],BL[417],BL[416],BL[415],BL[414],BL[413],BL[412],BL[411],BL[410],BL[409],BL[408],BL[407],BL[406],BL[405],BL[404],BL[403],BL[402],BL[401],BL[400],BL[399],BL[398],BL[397],BL[396],BL[395],BL[394],BL[393],BL[392],BL[391],BL[390],BL[389],BL[388],BL[387],BL[386],BL[385],BL[384],BL[383],BL[382],BL[381],BL[380],BL[379],BL[378],BL[377],BL[376],BL[375],BL[374],BL[373],BL[372],BL[371],BL[370],BL[369],BL[368],BL[367],BL[366],BL[365],BL[364],BL[363],BL[362],BL[361],BL[360],BL[359],BL[358],BL[357],BL[356],BL[355],BL[354],BL[353],BL[352],BL[351],BL[350],BL[349],BL[348],BL[347],BL[346],BL[345],BL[344],BL[343],BL[342],BL[341],BL[340],BL[339],BL[338],BL[337],BL[336],BL[335],BL[334],BL[333],BL[332],BL[331],BL[330],BL[329],BL[328],BL[327],BL[326],BL[325],BL[324],BL[323],BL[322],BL[321],BL[320],BL[319],BL[318],BL[317],BL[316],BL[315],BL[314],BL[313],BL[312],BL[311],BL[310],BL[309],BL[308],BL[307],BL[306],BL[305],BL[304],BL[303],BL[302],BL[301],BL[300],BL[299],BL[298],BL[297],BL[296],BL[295],BL[294],BL[293],BL[292],BL[291],BL[290],BL[289],BL[288],BL[287],BL[286],BL[285],BL[284],BL[283],BL[282],BL[281],BL[280],BL[279],BL[278],BL[277],BL[276],BL[275],BL[274],BL[273],BL[272],BL[271],BL[270],BL[269],BL[268],BL[267],BL[266],BL[265],BL[264],BL[263],BL[262],BL[261],BL[260],BL[259],BL[258],BL[257],BL[256],BL[255],BL[254],BL[253],BL[252],BL[251],BL[250],BL[249],BL[248],BL[247],BL[246],BL[245],BL[244],BL[243],BL[242],BL[241],BL[240],BL[239],BL[238],BL[237],BL[236],BL[235],BL[234],BL[233],BL[232],BL[231],BL[230],BL[229],BL[228],BL[227],BL[226],BL[225],BL[224],BL[223],BL[222],BL[221],BL[220],BL[219],BL[218],BL[217],BL[216],BL[215],BL[214],BL[213],BL[212],BL[211],BL[210],BL[209],BL[208],BL[207],BL[206],BL[205],BL[204],BL[203],BL[202],BL[201],BL[200],BL[199],BL[198],BL[197],BL[196],BL[195],BL[194],BL[193],BL[192],BL[191],BL[190],BL[189],BL[188],BL[187],BL[186],BL[185],BL[184],BL[183],BL[182],BL[181],BL[180],BL[179],BL[178],BL[177],BL[176],BL[175],BL[174],BL[173],BL[172],BL[171],BL[170],BL[169],BL[168],BL[167],BL[166],BL[165],BL[164],BL[163],BL[162],BL[161],BL[160],BL[159],BL[158],BL[157],BL[156],BL[155],BL[154],BL[153],BL[152],BL[151],BL[150],BL[149],BL[148],BL[147],BL[146],BL[145],BL[144],BL[143],BL[142],BL[141],BL[140],BL[139],BL[138],BL[137],BL[136],BL[135],BL[134],BL[133],BL[132],BL[131],BL[130],BL[129],BL[128],BL[127],BL[126],BL[125],BL[124],BL[123],BL[122],BL[121],BL[120],BL[119],BL[118],BL[117],BL[116],BL[115],BL[114],BL[113],BL[112],BL[111],BL[110],BL[109],BL[108],BL[107],BL[106],BL[105],BL[104],BL[103],BL[102],BL[101],BL[100],BL[99],BL[98],BL[97],BL[96],BL[95],BL[94],BL[93],BL[92],BL[91],BL[90],BL[89],BL[88],BL[87],BL[86],BL[85],BL[84],BL[83],BL[82],BL[81],BL[80],BL[79],BL[78],BL[77],BL[76],BL[75],BL[74],BL[73],BL[72],BL[71],BL[70],BL[69],BL[68],BL[67],BL[66],BL[65],BL[64],BL[63],BL[62],BL[61],BL[60],BL[59],BL[58],BL[57],BL[56],BL[55],BL[54],BL[53],BL[52],BL[51],BL[50],BL[49],BL[48],BL[47],BL[46],BL[45],BL[44],BL[43],BL[42],BL[41],BL[40],BL[39],BL[38],BL[37],BL[36],BL[35],BL[34],BL[33],BL[32],BL[31],BL[30],BL[29],BL[28],BL[27],BL[26],BL[25],BL[24],BL[23],BL[22],BL[21],BL[20],BL[19],BL[18],BL[17],BL[16],BL[15],BL[14],BL[13],BL[12],BL[11],BL[10],BL[9],BL[8],BL[7],BL[6],BL[5],BL[4],BL[3],BL[2],BL[1],BL[0]
*+ SA_RDY[143],SA_RDY[142],SA_RDY[141],SA_RDY[140],SA_RDY[139],SA_RDY[138],SA_RDY[137],SA_RDY[136],SA_RDY[135],SA_RDY[134],SA_RDY[133],SA_RDY[132],SA_RDY[131],SA_RDY[130],SA_RDY[129],SA_RDY[128],SA_RDY[127],SA_RDY[126],SA_RDY[125],SA_RDY[124],SA_RDY[123],SA_RDY[122],SA_RDY[121],SA_RDY[120],SA_RDY[119],SA_RDY[118],SA_RDY[117],SA_RDY[116],SA_RDY[115],SA_RDY[114],SA_RDY[113],SA_RDY[112],SA_RDY[111],SA_RDY[110],SA_RDY[109],SA_RDY[108],SA_RDY[107],SA_RDY[106],SA_RDY[105],SA_RDY[104],SA_RDY[103],SA_RDY[102],SA_RDY[101],SA_RDY[100],SA_RDY[99],SA_RDY[98],SA_RDY[97],SA_RDY[96],SA_RDY[95],SA_RDY[94],SA_RDY[93],SA_RDY[92],SA_RDY[91],SA_RDY[90],SA_RDY[89],SA_RDY[88],SA_RDY[87],SA_RDY[86],SA_RDY[85],SA_RDY[84],SA_RDY[83],SA_RDY[82],SA_RDY[81],SA_RDY[80],SA_RDY[79],SA_RDY[78],SA_RDY[77],SA_RDY[76],SA_RDY[75],SA_RDY[74],SA_RDY[73],SA_RDY[72],SA_RDY[71],SA_RDY[70],SA_RDY[69],SA_RDY[68],SA_RDY[67],SA_RDY[66],SA_RDY[65],SA_RDY[64],SA_RDY[63],SA_RDY[62],SA_RDY[61],SA_RDY[60],SA_RDY[59],SA_RDY[58],SA_RDY[57],SA_RDY[56],SA_RDY[55],SA_RDY[54],SA_RDY[53],SA_RDY[52],SA_RDY[51],SA_RDY[50],SA_RDY[49],SA_RDY[48],SA_RDY[47],SA_RDY[46],SA_RDY[45],SA_RDY[44],SA_RDY[43],SA_RDY[42],SA_RDY[41],SA_RDY[40],SA_RDY[39],SA_RDY[38],SA_RDY[37],SA_RDY[36],SA_RDY[35],SA_RDY[34],SA_RDY[33],SA_RDY[32],SA_RDY[31],SA_RDY[30],SA_RDY[29],SA_RDY[28],SA_RDY[27],SA_RDY[26],SA_RDY[25],SA_RDY[24],SA_RDY[23],SA_RDY[22],SA_RDY[21],SA_RDY[20],SA_RDY[19],SA_RDY[18],SA_RDY[17],SA_RDY[16],SA_RDY[15],SA_RDY[14],SA_RDY[13],SA_RDY[12],SA_RDY[11],SA_RDY[10],SA_RDY[9],SA_RDY[8],SA_RDY[7],SA_RDY[6],SA_RDY[5],SA_RDY[4],SA_RDY[3],SA_RDY[2],SA_RDY[1],SA_RDY[0]
*+ SA_DO[143],SA_DO[142],SA_DO[141],SA_DO[140],SA_DO[139],SA_DO[138],SA_DO[137],SA_DO[136],SA_DO[135],SA_DO[134],SA_DO[133],SA_DO[132],SA_DO[131],SA_DO[130],SA_DO[129],SA_DO[128],SA_DO[127],SA_DO[126],SA_DO[125],SA_DO[124],SA_DO[123],SA_DO[122],SA_DO[121],SA_DO[120],SA_DO[119],SA_DO[118],SA_DO[117],SA_DO[116],SA_DO[115],SA_DO[114],SA_DO[113],SA_DO[112],SA_DO[111],SA_DO[110],SA_DO[109],SA_DO[108],SA_DO[107],SA_DO[106],SA_DO[105],SA_DO[104],SA_DO[103],SA_DO[102],SA_DO[101],SA_DO[100],SA_DO[99],SA_DO[98],SA_DO[97],SA_DO[96],SA_DO[95],SA_DO[94],SA_DO[93],SA_DO[92],SA_DO[91],SA_DO[90],SA_DO[89],SA_DO[88],SA_DO[87],SA_DO[86],SA_DO[85],SA_DO[84],SA_DO[83],SA_DO[82],SA_DO[81],SA_DO[80],SA_DO[79],SA_DO[78],SA_DO[77],SA_DO[76],SA_DO[75],SA_DO[74],SA_DO[73],SA_DO[72],SA_DO[71],SA_DO[70],SA_DO[69],SA_DO[68],SA_DO[67],SA_DO[66],SA_DO[65],SA_DO[64],SA_DO[63],SA_DO[62],SA_DO[61],SA_DO[60],SA_DO[59],SA_DO[58],SA_DO[57],SA_DO[56],SA_DO[55],SA_DO[54],SA_DO[53],SA_DO[52],SA_DO[51],SA_DO[50],SA_DO[49],SA_DO[48],SA_DO[47],SA_DO[46],SA_DO[45],SA_DO[44],SA_DO[43],SA_DO[42],SA_DO[41],SA_DO[40],SA_DO[39],SA_DO[38],SA_DO[37],SA_DO[36],SA_DO[35],SA_DO[34],SA_DO[33],SA_DO[32],SA_DO[31],SA_DO[30],SA_DO[29],SA_DO[28],SA_DO[27],SA_DO[26],SA_DO[25],SA_DO[24],SA_DO[23],SA_DO[22],SA_DO[21],SA_DO[20],SA_DO[19],SA_DO[18],SA_DO[17],SA_DO[16],SA_DO[15],SA_DO[14],SA_DO[13],SA_DO[12],SA_DO[11],SA_DO[10],SA_DO[9],SA_DO[8],SA_DO[7],SA_DO[6],SA_DO[5],SA_DO[4],SA_DO[3],SA_DO[2],SA_DO[1],SA_DO[0] READ_MODE READ_REF[6],READ_REF[5],READ_REF[4],READ_REF[3],READ_REF[2],READ_REF[1],READ_REF[0]
*+ REF_MODE RESET_REF[6],RESET_REF[5],RESET_REF[4],RESET_REF[3],RESET_REF[2],RESET_REF[1],RESET_REF[0] SA_CLK
*+ SA_EN SET_REF[6],SET_REF[5],SET_REF[4],SET_REF[3],SET_REF[2],SET_REF[1],SET_REF[0]
*+ READ_SLICE_ARRAY_ENB_PRE_5[8],READ_SLICE_ARRAY_ENB_PRE_5[7],READ_SLICE_ARRAY_ENB_PRE_5[6],READ_SLICE_ARRAY_ENB_PRE_5[5],READ_SLICE_ARRAY_ENB_PRE_5[4],READ_SLICE_ARRAY_ENB_PRE_5[3],READ_SLICE_ARRAY_ENB_PRE_5[2],READ_SLICE_ARRAY_ENB_PRE_5[1],READ_SLICE_ARRAY_ENB_PRE_5[0]
*+ READ_SLICE_COL_ADDR3B_PRE_5[8],READ_SLICE_COL_ADDR3B_PRE_5[7],READ_SLICE_COL_ADDR3B_PRE_5[6],READ_SLICE_COL_ADDR3B_PRE_5[5],READ_SLICE_COL_ADDR3B_PRE_5[4],READ_SLICE_COL_ADDR3B_PRE_5[3],READ_SLICE_COL_ADDR3B_PRE_5[2],READ_SLICE_COL_ADDR3B_PRE_5[1],READ_SLICE_COL_ADDR3B_PRE_5[0]
*+ READ_SLICE_DI1_BUF[8],READ_SLICE_DI1_BUF[7],READ_SLICE_DI1_BUF[6],READ_SLICE_DI1_BUF[5],READ_SLICE_DI1_BUF[4],READ_SLICE_DI1_BUF[3],READ_SLICE_DI1_BUF[2],READ_SLICE_DI1_BUF[1],READ_SLICE_DI1_BUF[0]
*+ READ_SLICE_READ_REF4_BUF[8],READ_SLICE_READ_REF4_BUF[7],READ_SLICE_READ_REF4_BUF[6],READ_SLICE_READ_REF4_BUF[5],READ_SLICE_READ_REF4_BUF[4],READ_SLICE_READ_REF4_BUF[3],READ_SLICE_READ_REF4_BUF[2],READ_SLICE_READ_REF4_BUF[1],READ_SLICE_READ_REF4_BUF[0]
*+ READ_ROUT0_BLOCK_SA_EN_5[8],READ_ROUT0_BLOCK_SA_EN_5[7],READ_ROUT0_BLOCK_SA_EN_5[6],READ_ROUT0_BLOCK_SA_EN_5[5],READ_ROUT0_BLOCK_SA_EN_5[4],READ_ROUT0_BLOCK_SA_EN_5[3],READ_ROUT0_BLOCK_SA_EN_5[2],READ_ROUT0_BLOCK_SA_EN_5[1],READ_ROUT0_BLOCK_SA_EN_5[0]
*+ READ_ROUT0_BL_EN_5[8],READ_ROUT0_BL_EN_5[7],READ_ROUT0_BL_EN_5[6],READ_ROUT0_BL_EN_5[5],READ_ROUT0_BL_EN_5[4],READ_ROUT0_BL_EN_5[3],READ_ROUT0_BL_EN_5[2],READ_ROUT0_BL_EN_5[1],READ_ROUT0_BL_EN_5[0]
*+ READ_ROUT0_BLOCK_SA_EN[8],READ_ROUT0_BLOCK_SA_EN[7],READ_ROUT0_BLOCK_SA_EN[6],READ_ROUT0_BLOCK_SA_EN[5],READ_ROUT0_BLOCK_SA_EN[4],READ_ROUT0_BLOCK_SA_EN[3],READ_ROUT0_BLOCK_SA_EN[2],READ_ROUT0_BLOCK_SA_EN[1],READ_ROUT0_BLOCK_SA_EN[0]
*+ READ_ROUT0_COL_SELECT0_5[8],READ_ROUT0_COL_SELECT0_5[7],READ_ROUT0_COL_SELECT0_5[6],READ_ROUT0_COL_SELECT0_5[5],READ_ROUT0_COL_SELECT0_5[4],READ_ROUT0_COL_SELECT0_5[3],READ_ROUT0_COL_SELECT0_5[2],READ_ROUT0_COL_SELECT0_5[1],READ_ROUT0_COL_SELECT0_5[0]
*+ READ_SLICE_REF_MODE_BUF[8],READ_SLICE_REF_MODE_BUF[7],READ_SLICE_REF_MODE_BUF[6],READ_SLICE_REF_MODE_BUF[5],READ_SLICE_REF_MODE_BUF[4],READ_SLICE_REF_MODE_BUF[3],READ_SLICE_REF_MODE_BUF[2],READ_SLICE_REF_MODE_BUF[1],READ_SLICE_REF_MODE_BUF[0]
*+ READ_SLICE_RESET_REF4_BUF[8],READ_SLICE_RESET_REF4_BUF[7],READ_SLICE_RESET_REF4_BUF[6],READ_SLICE_RESET_REF4_BUF[5],READ_SLICE_RESET_REF4_BUF[4],READ_SLICE_RESET_REF4_BUF[3],READ_SLICE_RESET_REF4_BUF[2],READ_SLICE_RESET_REF4_BUF[1],READ_SLICE_RESET_REF4_BUF[0]
*+ READ_ROUT15_SA_CLK_BUF[8],READ_ROUT15_SA_CLK_BUF[7],READ_ROUT15_SA_CLK_BUF[6],READ_ROUT15_SA_CLK_BUF[5],READ_ROUT15_SA_CLK_BUF[4],READ_ROUT15_SA_CLK_BUF[3],READ_ROUT15_SA_CLK_BUF[2],READ_ROUT15_SA_CLK_BUF[1],READ_ROUT15_SA_CLK_BUF[0]
*+ READ_SLICE_SA_CLK_PRE[8],READ_SLICE_SA_CLK_PRE[7],READ_SLICE_SA_CLK_PRE[6],READ_SLICE_SA_CLK_PRE[5],READ_SLICE_SA_CLK_PRE[4],READ_SLICE_SA_CLK_PRE[3],READ_SLICE_SA_CLK_PRE[2],READ_SLICE_SA_CLK_PRE[1],READ_SLICE_SA_CLK_PRE[0]
*+ READ_SLICE_SA_EN_PRE[8],READ_SLICE_SA_EN_PRE[7],READ_SLICE_SA_EN_PRE[6],READ_SLICE_SA_EN_PRE[5],READ_SLICE_SA_EN_PRE[4],READ_SLICE_SA_EN_PRE[3],READ_SLICE_SA_EN_PRE[2],READ_SLICE_SA_EN_PRE[1],READ_SLICE_SA_EN_PRE[0]
*+ READ_SLICE_SET_REF4_BUF[8],READ_SLICE_SET_REF4_BUF[7],READ_SLICE_SET_REF4_BUF[6],READ_SLICE_SET_REF4_BUF[5],READ_SLICE_SET_REF4_BUF[4],READ_SLICE_SET_REF4_BUF[3],READ_SLICE_SET_REF4_BUF[2],READ_SLICE_SET_REF4_BUF[1],READ_SLICE_SET_REF4_BUF[0]
*+ READ_SLICE_SLICE_SELECTB_PRE_5[8],READ_SLICE_SLICE_SELECTB_PRE_5[7],READ_SLICE_SLICE_SELECTB_PRE_5[6],READ_SLICE_SLICE_SELECTB_PRE_5[5],READ_SLICE_SLICE_SELECTB_PRE_5[4],READ_SLICE_SLICE_SELECTB_PRE_5[3],READ_SLICE_SLICE_SELECTB_PRE_5[2],READ_SLICE_SLICE_SELECTB_PRE_5[1],READ_SLICE_SLICE_SELECTB_PRE_5[0]
*+ READ_SLICE_SLICE_SELECT_PRE[8],READ_SLICE_SLICE_SELECT_PRE[7],READ_SLICE_SLICE_SELECT_PRE[6],READ_SLICE_SLICE_SELECT_PRE[5],READ_SLICE_SLICE_SELECT_PRE[4],READ_SLICE_SLICE_SELECT_PRE[3],READ_SLICE_SLICE_SELECT_PRE[2],READ_SLICE_SLICE_SELECT_PRE[1],READ_SLICE_SLICE_SELECT_PRE[0]
*+ READ_SLICE_WEB_PRE_5[8],READ_SLICE_WEB_PRE_5[7],READ_SLICE_WEB_PRE_5[6],READ_SLICE_WEB_PRE_5[5],READ_SLICE_WEB_PRE_5[4],READ_SLICE_WEB_PRE_5[3],READ_SLICE_WEB_PRE_5[2],READ_SLICE_WEB_PRE_5[1],READ_SLICE_WEB_PRE_5[0]
*+ READ_ROUT15_WE_5_BUF[8],READ_ROUT15_WE_5_BUF[7],READ_ROUT15_WE_5_BUF[6],READ_ROUT15_WE_5_BUF[5],READ_ROUT15_WE_5_BUF[4],READ_ROUT15_WE_5_BUF[3],READ_ROUT15_WE_5_BUF[2],READ_ROUT15_WE_5_BUF[1],READ_ROUT15_WE_5_BUF[0] COL_ADDR_BAR_5[0] WE_5 ARRAY_EN_BAR_5 SLICE_SELECT_BAR_5[8] SLICE_SELECT[8] READ_DI0
*+ READ_SET_REF[1] READ_RESET_REF[0] READ_READ_REF[0] READ_READ_MODE READ_SA_CLK READ_REF_MODE
*.ipin VBL_READ
*.ipin AVDD
*.ipin AVSS
*.ipin VDD
*.ipin VSA
*.ipin VSS
*.ipin
*+ DI[15],DI[14],DI[13],DI[12],DI[11],DI[10],DI[9],DI[8],DI[7],DI[6],DI[5],DI[4],DI[3],DI[2],DI[1],DI[0]
*.ipin ARRAY_EN
*.ipin
*+ COL_ADDR[7],COL_ADDR[6],COL_ADDR[5],COL_ADDR[4],COL_ADDR[3],COL_ADDR[2],COL_ADDR[1],COL_ADDR[0]
*.ipin WE
*.iopin
*+ BL[2303],BL[2302],BL[2301],BL[2300],BL[2299],BL[2298],BL[2297],BL[2296],BL[2295],BL[2294],BL[2293],BL[2292],BL[2291],BL[2290],BL[2289],BL[2288],BL[2287],BL[2286],BL[2285],BL[2284],BL[2283],BL[2282],BL[2281],BL[2280],BL[2279],BL[2278],BL[2277],BL[2276],BL[2275],BL[2274],BL[2273],BL[2272],BL[2271],BL[2270],BL[2269],BL[2268],BL[2267],BL[2266],BL[2265],BL[2264],BL[2263],BL[2262],BL[2261],BL[2260],BL[2259],BL[2258],BL[2257],BL[2256],BL[2255],BL[2254],BL[2253],BL[2252],BL[2251],BL[2250],BL[2249],BL[2248],BL[2247],BL[2246],BL[2245],BL[2244],BL[2243],BL[2242],BL[2241],BL[2240],BL[2239],BL[2238],BL[2237],BL[2236],BL[2235],BL[2234],BL[2233],BL[2232],BL[2231],BL[2230],BL[2229],BL[2228],BL[2227],BL[2226],BL[2225],BL[2224],BL[2223],BL[2222],BL[2221],BL[2220],BL[2219],BL[2218],BL[2217],BL[2216],BL[2215],BL[2214],BL[2213],BL[2212],BL[2211],BL[2210],BL[2209],BL[2208],BL[2207],BL[2206],BL[2205],BL[2204],BL[2203],BL[2202],BL[2201],BL[2200],BL[2199],BL[2198],BL[2197],BL[2196],BL[2195],BL[2194],BL[2193],BL[2192],BL[2191],BL[2190],BL[2189],BL[2188],BL[2187],BL[2186],BL[2185],BL[2184],BL[2183],BL[2182],BL[2181],BL[2180],BL[2179],BL[2178],BL[2177],BL[2176],BL[2175],BL[2174],BL[2173],BL[2172],BL[2171],BL[2170],BL[2169],BL[2168],BL[2167],BL[2166],BL[2165],BL[2164],BL[2163],BL[2162],BL[2161],BL[2160],BL[2159],BL[2158],BL[2157],BL[2156],BL[2155],BL[2154],BL[2153],BL[2152],BL[2151],BL[2150],BL[2149],BL[2148],BL[2147],BL[2146],BL[2145],BL[2144],BL[2143],BL[2142],BL[2141],BL[2140],BL[2139],BL[2138],BL[2137],BL[2136],BL[2135],BL[2134],BL[2133],BL[2132],BL[2131],BL[2130],BL[2129],BL[2128],BL[2127],BL[2126],BL[2125],BL[2124],BL[2123],BL[2122],BL[2121],BL[2120],BL[2119],BL[2118],BL[2117],BL[2116],BL[2115],BL[2114],BL[2113],BL[2112],BL[2111],BL[2110],BL[2109],BL[2108],BL[2107],BL[2106],BL[2105],BL[2104],BL[2103],BL[2102],BL[2101],BL[2100],BL[2099],BL[2098],BL[2097],BL[2096],BL[2095],BL[2094],BL[2093],BL[2092],BL[2091],BL[2090],BL[2089],BL[2088],BL[2087],BL[2086],BL[2085],BL[2084],BL[2083],BL[2082],BL[2081],BL[2080],BL[2079],BL[2078],BL[2077],BL[2076],BL[2075],BL[2074],BL[2073],BL[2072],BL[2071],BL[2070],BL[2069],BL[2068],BL[2067],BL[2066],BL[2065],BL[2064],BL[2063],BL[2062],BL[2061],BL[2060],BL[2059],BL[2058],BL[2057],BL[2056],BL[2055],BL[2054],BL[2053],BL[2052],BL[2051],BL[2050],BL[2049],BL[2048],BL[2047],BL[2046],BL[2045],BL[2044],BL[2043],BL[2042],BL[2041],BL[2040],BL[2039],BL[2038],BL[2037],BL[2036],BL[2035],BL[2034],BL[2033],BL[2032],BL[2031],BL[2030],BL[2029],BL[2028],BL[2027],BL[2026],BL[2025],BL[2024],BL[2023],BL[2022],BL[2021],BL[2020],BL[2019],BL[2018],BL[2017],BL[2016],BL[2015],BL[2014],BL[2013],BL[2012],BL[2011],BL[2010],BL[2009],BL[2008],BL[2007],BL[2006],BL[2005],BL[2004],BL[2003],BL[2002],BL[2001],BL[2000],BL[1999],BL[1998],BL[1997],BL[1996],BL[1995],BL[1994],BL[1993],BL[1992],BL[1991],BL[1990],BL[1989],BL[1988],BL[1987],BL[1986],BL[1985],BL[1984],BL[1983],BL[1982],BL[1981],BL[1980],BL[1979],BL[1978],BL[1977],BL[1976],BL[1975],BL[1974],BL[1973],BL[1972],BL[1971],BL[1970],BL[1969],BL[1968],BL[1967],BL[1966],BL[1965],BL[1964],BL[1963],BL[1962],BL[1961],BL[1960],BL[1959],BL[1958],BL[1957],BL[1956],BL[1955],BL[1954],BL[1953],BL[1952],BL[1951],BL[1950],BL[1949],BL[1948],BL[1947],BL[1946],BL[1945],BL[1944],BL[1943],BL[1942],BL[1941],BL[1940],BL[1939],BL[1938],BL[1937],BL[1936],BL[1935],BL[1934],BL[1933],BL[1932],BL[1931],BL[1930],BL[1929],BL[1928],BL[1927],BL[1926],BL[1925],BL[1924],BL[1923],BL[1922],BL[1921],BL[1920],BL[1919],BL[1918],BL[1917],BL[1916],BL[1915],BL[1914],BL[1913],BL[1912],BL[1911],BL[1910],BL[1909],BL[1908],BL[1907],BL[1906],BL[1905],BL[1904],BL[1903],BL[1902],BL[1901],BL[1900],BL[1899],BL[1898],BL[1897],BL[1896],BL[1895],BL[1894],BL[1893],BL[1892],BL[1891],BL[1890],BL[1889],BL[1888],BL[1887],BL[1886],BL[1885],BL[1884],BL[1883],BL[1882],BL[1881],BL[1880],BL[1879],BL[1878],BL[1877],BL[1876],BL[1875],BL[1874],BL[1873],BL[1872],BL[1871],BL[1870],BL[1869],BL[1868],BL[1867],BL[1866],BL[1865],BL[1864],BL[1863],BL[1862],BL[1861],BL[1860],BL[1859],BL[1858],BL[1857],BL[1856],BL[1855],BL[1854],BL[1853],BL[1852],BL[1851],BL[1850],BL[1849],BL[1848],BL[1847],BL[1846],BL[1845],BL[1844],BL[1843],BL[1842],BL[1841],BL[1840],BL[1839],BL[1838],BL[1837],BL[1836],BL[1835],BL[1834],BL[1833],BL[1832],BL[1831],BL[1830],BL[1829],BL[1828],BL[1827],BL[1826],BL[1825],BL[1824],BL[1823],BL[1822],BL[1821],BL[1820],BL[1819],BL[1818],BL[1817],BL[1816],BL[1815],BL[1814],BL[1813],BL[1812],BL[1811],BL[1810],BL[1809],BL[1808],BL[1807],BL[1806],BL[1805],BL[1804],BL[1803],BL[1802],BL[1801],BL[1800],BL[1799],BL[1798],BL[1797],BL[1796],BL[1795],BL[1794],BL[1793],BL[1792],BL[1791],BL[1790],BL[1789],BL[1788],BL[1787],BL[1786],BL[1785],BL[1784],BL[1783],BL[1782],BL[1781],BL[1780],BL[1779],BL[1778],BL[1777],BL[1776],BL[1775],BL[1774],BL[1773],BL[1772],BL[1771],BL[1770],BL[1769],BL[1768],BL[1767],BL[1766],BL[1765],BL[1764],BL[1763],BL[1762],BL[1761],BL[1760],BL[1759],BL[1758],BL[1757],BL[1756],BL[1755],BL[1754],BL[1753],BL[1752],BL[1751],BL[1750],BL[1749],BL[1748],BL[1747],BL[1746],BL[1745],BL[1744],BL[1743],BL[1742],BL[1741],BL[1740],BL[1739],BL[1738],BL[1737],BL[1736],BL[1735],BL[1734],BL[1733],BL[1732],BL[1731],BL[1730],BL[1729],BL[1728],BL[1727],BL[1726],BL[1725],BL[1724],BL[1723],BL[1722],BL[1721],BL[1720],BL[1719],BL[1718],BL[1717],BL[1716],BL[1715],BL[1714],BL[1713],BL[1712],BL[1711],BL[1710],BL[1709],BL[1708],BL[1707],BL[1706],BL[1705],BL[1704],BL[1703],BL[1702],BL[1701],BL[1700],BL[1699],BL[1698],BL[1697],BL[1696],BL[1695],BL[1694],BL[1693],BL[1692],BL[1691],BL[1690],BL[1689],BL[1688],BL[1687],BL[1686],BL[1685],BL[1684],BL[1683],BL[1682],BL[1681],BL[1680],BL[1679],BL[1678],BL[1677],BL[1676],BL[1675],BL[1674],BL[1673],BL[1672],BL[1671],BL[1670],BL[1669],BL[1668],BL[1667],BL[1666],BL[1665],BL[1664],BL[1663],BL[1662],BL[1661],BL[1660],BL[1659],BL[1658],BL[1657],BL[1656],BL[1655],BL[1654],BL[1653],BL[1652],BL[1651],BL[1650],BL[1649],BL[1648],BL[1647],BL[1646],BL[1645],BL[1644],BL[1643],BL[1642],BL[1641],BL[1640],BL[1639],BL[1638],BL[1637],BL[1636],BL[1635],BL[1634],BL[1633],BL[1632],BL[1631],BL[1630],BL[1629],BL[1628],BL[1627],BL[1626],BL[1625],BL[1624],BL[1623],BL[1622],BL[1621],BL[1620],BL[1619],BL[1618],BL[1617],BL[1616],BL[1615],BL[1614],BL[1613],BL[1612],BL[1611],BL[1610],BL[1609],BL[1608],BL[1607],BL[1606],BL[1605],BL[1604],BL[1603],BL[1602],BL[1601],BL[1600],BL[1599],BL[1598],BL[1597],BL[1596],BL[1595],BL[1594],BL[1593],BL[1592],BL[1591],BL[1590],BL[1589],BL[1588],BL[1587],BL[1586],BL[1585],BL[1584],BL[1583],BL[1582],BL[1581],BL[1580],BL[1579],BL[1578],BL[1577],BL[1576],BL[1575],BL[1574],BL[1573],BL[1572],BL[1571],BL[1570],BL[1569],BL[1568],BL[1567],BL[1566],BL[1565],BL[1564],BL[1563],BL[1562],BL[1561],BL[1560],BL[1559],BL[1558],BL[1557],BL[1556],BL[1555],BL[1554],BL[1553],BL[1552],BL[1551],BL[1550],BL[1549],BL[1548],BL[1547],BL[1546],BL[1545],BL[1544],BL[1543],BL[1542],BL[1541],BL[1540],BL[1539],BL[1538],BL[1537],BL[1536],BL[1535],BL[1534],BL[1533],BL[1532],BL[1531],BL[1530],BL[1529],BL[1528],BL[1527],BL[1526],BL[1525],BL[1524],BL[1523],BL[1522],BL[1521],BL[1520],BL[1519],BL[1518],BL[1517],BL[1516],BL[1515],BL[1514],BL[1513],BL[1512],BL[1511],BL[1510],BL[1509],BL[1508],BL[1507],BL[1506],BL[1505],BL[1504],BL[1503],BL[1502],BL[1501],BL[1500],BL[1499],BL[1498],BL[1497],BL[1496],BL[1495],BL[1494],BL[1493],BL[1492],BL[1491],BL[1490],BL[1489],BL[1488],BL[1487],BL[1486],BL[1485],BL[1484],BL[1483],BL[1482],BL[1481],BL[1480],BL[1479],BL[1478],BL[1477],BL[1476],BL[1475],BL[1474],BL[1473],BL[1472],BL[1471],BL[1470],BL[1469],BL[1468],BL[1467],BL[1466],BL[1465],BL[1464],BL[1463],BL[1462],BL[1461],BL[1460],BL[1459],BL[1458],BL[1457],BL[1456],BL[1455],BL[1454],BL[1453],BL[1452],BL[1451],BL[1450],BL[1449],BL[1448],BL[1447],BL[1446],BL[1445],BL[1444],BL[1443],BL[1442],BL[1441],BL[1440],BL[1439],BL[1438],BL[1437],BL[1436],BL[1435],BL[1434],BL[1433],BL[1432],BL[1431],BL[1430],BL[1429],BL[1428],BL[1427],BL[1426],BL[1425],BL[1424],BL[1423],BL[1422],BL[1421],BL[1420],BL[1419],BL[1418],BL[1417],BL[1416],BL[1415],BL[1414],BL[1413],BL[1412],BL[1411],BL[1410],BL[1409],BL[1408],BL[1407],BL[1406],BL[1405],BL[1404],BL[1403],BL[1402],BL[1401],BL[1400],BL[1399],BL[1398],BL[1397],BL[1396],BL[1395],BL[1394],BL[1393],BL[1392],BL[1391],BL[1390],BL[1389],BL[1388],BL[1387],BL[1386],BL[1385],BL[1384],BL[1383],BL[1382],BL[1381],BL[1380],BL[1379],BL[1378],BL[1377],BL[1376],BL[1375],BL[1374],BL[1373],BL[1372],BL[1371],BL[1370],BL[1369],BL[1368],BL[1367],BL[1366],BL[1365],BL[1364],BL[1363],BL[1362],BL[1361],BL[1360],BL[1359],BL[1358],BL[1357],BL[1356],BL[1355],BL[1354],BL[1353],BL[1352],BL[1351],BL[1350],BL[1349],BL[1348],BL[1347],BL[1346],BL[1345],BL[1344],BL[1343],BL[1342],BL[1341],BL[1340],BL[1339],BL[1338],BL[1337],BL[1336],BL[1335],BL[1334],BL[1333],BL[1332],BL[1331],BL[1330],BL[1329],BL[1328],BL[1327],BL[1326],BL[1325],BL[1324],BL[1323],BL[1322],BL[1321],BL[1320],BL[1319],BL[1318],BL[1317],BL[1316],BL[1315],BL[1314],BL[1313],BL[1312],BL[1311],BL[1310],BL[1309],BL[1308],BL[1307],BL[1306],BL[1305],BL[1304],BL[1303],BL[1302],BL[1301],BL[1300],BL[1299],BL[1298],BL[1297],BL[1296],BL[1295],BL[1294],BL[1293],BL[1292],BL[1291],BL[1290],BL[1289],BL[1288],BL[1287],BL[1286],BL[1285],BL[1284],BL[1283],BL[1282],BL[1281],BL[1280],BL[1279],BL[1278],BL[1277],BL[1276],BL[1275],BL[1274],BL[1273],BL[1272],BL[1271],BL[1270],BL[1269],BL[1268],BL[1267],BL[1266],BL[1265],BL[1264],BL[1263],BL[1262],BL[1261],BL[1260],BL[1259],BL[1258],BL[1257],BL[1256],BL[1255],BL[1254],BL[1253],BL[1252],BL[1251],BL[1250],BL[1249],BL[1248],BL[1247],BL[1246],BL[1245],BL[1244],BL[1243],BL[1242],BL[1241],BL[1240],BL[1239],BL[1238],BL[1237],BL[1236],BL[1235],BL[1234],BL[1233],BL[1232],BL[1231],BL[1230],BL[1229],BL[1228],BL[1227],BL[1226],BL[1225],BL[1224],BL[1223],BL[1222],BL[1221],BL[1220],BL[1219],BL[1218],BL[1217],BL[1216],BL[1215],BL[1214],BL[1213],BL[1212],BL[1211],BL[1210],BL[1209],BL[1208],BL[1207],BL[1206],BL[1205],BL[1204],BL[1203],BL[1202],BL[1201],BL[1200],BL[1199],BL[1198],BL[1197],BL[1196],BL[1195],BL[1194],BL[1193],BL[1192],BL[1191],BL[1190],BL[1189],BL[1188],BL[1187],BL[1186],BL[1185],BL[1184],BL[1183],BL[1182],BL[1181],BL[1180],BL[1179],BL[1178],BL[1177],BL[1176],BL[1175],BL[1174],BL[1173],BL[1172],BL[1171],BL[1170],BL[1169],BL[1168],BL[1167],BL[1166],BL[1165],BL[1164],BL[1163],BL[1162],BL[1161],BL[1160],BL[1159],BL[1158],BL[1157],BL[1156],BL[1155],BL[1154],BL[1153],BL[1152],BL[1151],BL[1150],BL[1149],BL[1148],BL[1147],BL[1146],BL[1145],BL[1144],BL[1143],BL[1142],BL[1141],BL[1140],BL[1139],BL[1138],BL[1137],BL[1136],BL[1135],BL[1134],BL[1133],BL[1132],BL[1131],BL[1130],BL[1129],BL[1128],BL[1127],BL[1126],BL[1125],BL[1124],BL[1123],BL[1122],BL[1121],BL[1120],BL[1119],BL[1118],BL[1117],BL[1116],BL[1115],BL[1114],BL[1113],BL[1112],BL[1111],BL[1110],BL[1109],BL[1108],BL[1107],BL[1106],BL[1105],BL[1104],BL[1103],BL[1102],BL[1101],BL[1100],BL[1099],BL[1098],BL[1097],BL[1096],BL[1095],BL[1094],BL[1093],BL[1092],BL[1091],BL[1090],BL[1089],BL[1088],BL[1087],BL[1086],BL[1085],BL[1084],BL[1083],BL[1082],BL[1081],BL[1080],BL[1079],BL[1078],BL[1077],BL[1076],BL[1075],BL[1074],BL[1073],BL[1072],BL[1071],BL[1070],BL[1069],BL[1068],BL[1067],BL[1066],BL[1065],BL[1064],BL[1063],BL[1062],BL[1061],BL[1060],BL[1059],BL[1058],BL[1057],BL[1056],BL[1055],BL[1054],BL[1053],BL[1052],BL[1051],BL[1050],BL[1049],BL[1048],BL[1047],BL[1046],BL[1045],BL[1044],BL[1043],BL[1042],BL[1041],BL[1040],BL[1039],BL[1038],BL[1037],BL[1036],BL[1035],BL[1034],BL[1033],BL[1032],BL[1031],BL[1030],BL[1029],BL[1028],BL[1027],BL[1026],BL[1025],BL[1024],BL[1023],BL[1022],BL[1021],BL[1020],BL[1019],BL[1018],BL[1017],BL[1016],BL[1015],BL[1014],BL[1013],BL[1012],BL[1011],BL[1010],BL[1009],BL[1008],BL[1007],BL[1006],BL[1005],BL[1004],BL[1003],BL[1002],BL[1001],BL[1000],BL[999],BL[998],BL[997],BL[996],BL[995],BL[994],BL[993],BL[992],BL[991],BL[990],BL[989],BL[988],BL[987],BL[986],BL[985],BL[984],BL[983],BL[982],BL[981],BL[980],BL[979],BL[978],BL[977],BL[976],BL[975],BL[974],BL[973],BL[972],BL[971],BL[970],BL[969],BL[968],BL[967],BL[966],BL[965],BL[964],BL[963],BL[962],BL[961],BL[960],BL[959],BL[958],BL[957],BL[956],BL[955],BL[954],BL[953],BL[952],BL[951],BL[950],BL[949],BL[948],BL[947],BL[946],BL[945],BL[944],BL[943],BL[942],BL[941],BL[940],BL[939],BL[938],BL[937],BL[936],BL[935],BL[934],BL[933],BL[932],BL[931],BL[930],BL[929],BL[928],BL[927],BL[926],BL[925],BL[924],BL[923],BL[922],BL[921],BL[920],BL[919],BL[918],BL[917],BL[916],BL[915],BL[914],BL[913],BL[912],BL[911],BL[910],BL[909],BL[908],BL[907],BL[906],BL[905],BL[904],BL[903],BL[902],BL[901],BL[900],BL[899],BL[898],BL[897],BL[896],BL[895],BL[894],BL[893],BL[892],BL[891],BL[890],BL[889],BL[888],BL[887],BL[886],BL[885],BL[884],BL[883],BL[882],BL[881],BL[880],BL[879],BL[878],BL[877],BL[876],BL[875],BL[874],BL[873],BL[872],BL[871],BL[870],BL[869],BL[868],BL[867],BL[866],BL[865],BL[864],BL[863],BL[862],BL[861],BL[860],BL[859],BL[858],BL[857],BL[856],BL[855],BL[854],BL[853],BL[852],BL[851],BL[850],BL[849],BL[848],BL[847],BL[846],BL[845],BL[844],BL[843],BL[842],BL[841],BL[840],BL[839],BL[838],BL[837],BL[836],BL[835],BL[834],BL[833],BL[832],BL[831],BL[830],BL[829],BL[828],BL[827],BL[826],BL[825],BL[824],BL[823],BL[822],BL[821],BL[820],BL[819],BL[818],BL[817],BL[816],BL[815],BL[814],BL[813],BL[812],BL[811],BL[810],BL[809],BL[808],BL[807],BL[806],BL[805],BL[804],BL[803],BL[802],BL[801],BL[800],BL[799],BL[798],BL[797],BL[796],BL[795],BL[794],BL[793],BL[792],BL[791],BL[790],BL[789],BL[788],BL[787],BL[786],BL[785],BL[784],BL[783],BL[782],BL[781],BL[780],BL[779],BL[778],BL[777],BL[776],BL[775],BL[774],BL[773],BL[772],BL[771],BL[770],BL[769],BL[768],BL[767],BL[766],BL[765],BL[764],BL[763],BL[762],BL[761],BL[760],BL[759],BL[758],BL[757],BL[756],BL[755],BL[754],BL[753],BL[752],BL[751],BL[750],BL[749],BL[748],BL[747],BL[746],BL[745],BL[744],BL[743],BL[742],BL[741],BL[740],BL[739],BL[738],BL[737],BL[736],BL[735],BL[734],BL[733],BL[732],BL[731],BL[730],BL[729],BL[728],BL[727],BL[726],BL[725],BL[724],BL[723],BL[722],BL[721],BL[720],BL[719],BL[718],BL[717],BL[716],BL[715],BL[714],BL[713],BL[712],BL[711],BL[710],BL[709],BL[708],BL[707],BL[706],BL[705],BL[704],BL[703],BL[702],BL[701],BL[700],BL[699],BL[698],BL[697],BL[696],BL[695],BL[694],BL[693],BL[692],BL[691],BL[690],BL[689],BL[688],BL[687],BL[686],BL[685],BL[684],BL[683],BL[682],BL[681],BL[680],BL[679],BL[678],BL[677],BL[676],BL[675],BL[674],BL[673],BL[672],BL[671],BL[670],BL[669],BL[668],BL[667],BL[666],BL[665],BL[664],BL[663],BL[662],BL[661],BL[660],BL[659],BL[658],BL[657],BL[656],BL[655],BL[654],BL[653],BL[652],BL[651],BL[650],BL[649],BL[648],BL[647],BL[646],BL[645],BL[644],BL[643],BL[642],BL[641],BL[640],BL[639],BL[638],BL[637],BL[636],BL[635],BL[634],BL[633],BL[632],BL[631],BL[630],BL[629],BL[628],BL[627],BL[626],BL[625],BL[624],BL[623],BL[622],BL[621],BL[620],BL[619],BL[618],BL[617],BL[616],BL[615],BL[614],BL[613],BL[612],BL[611],BL[610],BL[609],BL[608],BL[607],BL[606],BL[605],BL[604],BL[603],BL[602],BL[601],BL[600],BL[599],BL[598],BL[597],BL[596],BL[595],BL[594],BL[593],BL[592],BL[591],BL[590],BL[589],BL[588],BL[587],BL[586],BL[585],BL[584],BL[583],BL[582],BL[581],BL[580],BL[579],BL[578],BL[577],BL[576],BL[575],BL[574],BL[573],BL[572],BL[571],BL[570],BL[569],BL[568],BL[567],BL[566],BL[565],BL[564],BL[563],BL[562],BL[561],BL[560],BL[559],BL[558],BL[557],BL[556],BL[555],BL[554],BL[553],BL[552],BL[551],BL[550],BL[549],BL[548],BL[547],BL[546],BL[545],BL[544],BL[543],BL[542],BL[541],BL[540],BL[539],BL[538],BL[537],BL[536],BL[535],BL[534],BL[533],BL[532],BL[531],BL[530],BL[529],BL[528],BL[527],BL[526],BL[525],BL[524],BL[523],BL[522],BL[521],BL[520],BL[519],BL[518],BL[517],BL[516],BL[515],BL[514],BL[513],BL[512],BL[511],BL[510],BL[509],BL[508],BL[507],BL[506],BL[505],BL[504],BL[503],BL[502],BL[501],BL[500],BL[499],BL[498],BL[497],BL[496],BL[495],BL[494],BL[493],BL[492],BL[491],BL[490],BL[489],BL[488],BL[487],BL[486],BL[485],BL[484],BL[483],BL[482],BL[481],BL[480],BL[479],BL[478],BL[477],BL[476],BL[475],BL[474],BL[473],BL[472],BL[471],BL[470],BL[469],BL[468],BL[467],BL[466],BL[465],BL[464],BL[463],BL[462],BL[461],BL[460],BL[459],BL[458],BL[457],BL[456],BL[455],BL[454],BL[453],BL[452],BL[451],BL[450],BL[449],BL[448],BL[447],BL[446],BL[445],BL[444],BL[443],BL[442],BL[441],BL[440],BL[439],BL[438],BL[437],BL[436],BL[435],BL[434],BL[433],BL[432],BL[431],BL[430],BL[429],BL[428],BL[427],BL[426],BL[425],BL[424],BL[423],BL[422],BL[421],BL[420],BL[419],BL[418],BL[417],BL[416],BL[415],BL[414],BL[413],BL[412],BL[411],BL[410],BL[409],BL[408],BL[407],BL[406],BL[405],BL[404],BL[403],BL[402],BL[401],BL[400],BL[399],BL[398],BL[397],BL[396],BL[395],BL[394],BL[393],BL[392],BL[391],BL[390],BL[389],BL[388],BL[387],BL[386],BL[385],BL[384],BL[383],BL[382],BL[381],BL[380],BL[379],BL[378],BL[377],BL[376],BL[375],BL[374],BL[373],BL[372],BL[371],BL[370],BL[369],BL[368],BL[367],BL[366],BL[365],BL[364],BL[363],BL[362],BL[361],BL[360],BL[359],BL[358],BL[357],BL[356],BL[355],BL[354],BL[353],BL[352],BL[351],BL[350],BL[349],BL[348],BL[347],BL[346],BL[345],BL[344],BL[343],BL[342],BL[341],BL[340],BL[339],BL[338],BL[337],BL[336],BL[335],BL[334],BL[333],BL[332],BL[331],BL[330],BL[329],BL[328],BL[327],BL[326],BL[325],BL[324],BL[323],BL[322],BL[321],BL[320],BL[319],BL[318],BL[317],BL[316],BL[315],BL[314],BL[313],BL[312],BL[311],BL[310],BL[309],BL[308],BL[307],BL[306],BL[305],BL[304],BL[303],BL[302],BL[301],BL[300],BL[299],BL[298],BL[297],BL[296],BL[295],BL[294],BL[293],BL[292],BL[291],BL[290],BL[289],BL[288],BL[287],BL[286],BL[285],BL[284],BL[283],BL[282],BL[281],BL[280],BL[279],BL[278],BL[277],BL[276],BL[275],BL[274],BL[273],BL[272],BL[271],BL[270],BL[269],BL[268],BL[267],BL[266],BL[265],BL[264],BL[263],BL[262],BL[261],BL[260],BL[259],BL[258],BL[257],BL[256],BL[255],BL[254],BL[253],BL[252],BL[251],BL[250],BL[249],BL[248],BL[247],BL[246],BL[245],BL[244],BL[243],BL[242],BL[241],BL[240],BL[239],BL[238],BL[237],BL[236],BL[235],BL[234],BL[233],BL[232],BL[231],BL[230],BL[229],BL[228],BL[227],BL[226],BL[225],BL[224],BL[223],BL[222],BL[221],BL[220],BL[219],BL[218],BL[217],BL[216],BL[215],BL[214],BL[213],BL[212],BL[211],BL[210],BL[209],BL[208],BL[207],BL[206],BL[205],BL[204],BL[203],BL[202],BL[201],BL[200],BL[199],BL[198],BL[197],BL[196],BL[195],BL[194],BL[193],BL[192],BL[191],BL[190],BL[189],BL[188],BL[187],BL[186],BL[185],BL[184],BL[183],BL[182],BL[181],BL[180],BL[179],BL[178],BL[177],BL[176],BL[175],BL[174],BL[173],BL[172],BL[171],BL[170],BL[169],BL[168],BL[167],BL[166],BL[165],BL[164],BL[163],BL[162],BL[161],BL[160],BL[159],BL[158],BL[157],BL[156],BL[155],BL[154],BL[153],BL[152],BL[151],BL[150],BL[149],BL[148],BL[147],BL[146],BL[145],BL[144],BL[143],BL[142],BL[141],BL[140],BL[139],BL[138],BL[137],BL[136],BL[135],BL[134],BL[133],BL[132],BL[131],BL[130],BL[129],BL[128],BL[127],BL[126],BL[125],BL[124],BL[123],BL[122],BL[121],BL[120],BL[119],BL[118],BL[117],BL[116],BL[115],BL[114],BL[113],BL[112],BL[111],BL[110],BL[109],BL[108],BL[107],BL[106],BL[105],BL[104],BL[103],BL[102],BL[101],BL[100],BL[99],BL[98],BL[97],BL[96],BL[95],BL[94],BL[93],BL[92],BL[91],BL[90],BL[89],BL[88],BL[87],BL[86],BL[85],BL[84],BL[83],BL[82],BL[81],BL[80],BL[79],BL[78],BL[77],BL[76],BL[75],BL[74],BL[73],BL[72],BL[71],BL[70],BL[69],BL[68],BL[67],BL[66],BL[65],BL[64],BL[63],BL[62],BL[61],BL[60],BL[59],BL[58],BL[57],BL[56],BL[55],BL[54],BL[53],BL[52],BL[51],BL[50],BL[49],BL[48],BL[47],BL[46],BL[45],BL[44],BL[43],BL[42],BL[41],BL[40],BL[39],BL[38],BL[37],BL[36],BL[35],BL[34],BL[33],BL[32],BL[31],BL[30],BL[29],BL[28],BL[27],BL[26],BL[25],BL[24],BL[23],BL[22],BL[21],BL[20],BL[19],BL[18],BL[17],BL[16],BL[15],BL[14],BL[13],BL[12],BL[11],BL[10],BL[9],BL[8],BL[7],BL[6],BL[5],BL[4],BL[3],BL[2],BL[1],BL[0]
*.opin
*+ SA_RDY[143],SA_RDY[142],SA_RDY[141],SA_RDY[140],SA_RDY[139],SA_RDY[138],SA_RDY[137],SA_RDY[136],SA_RDY[135],SA_RDY[134],SA_RDY[133],SA_RDY[132],SA_RDY[131],SA_RDY[130],SA_RDY[129],SA_RDY[128],SA_RDY[127],SA_RDY[126],SA_RDY[125],SA_RDY[124],SA_RDY[123],SA_RDY[122],SA_RDY[121],SA_RDY[120],SA_RDY[119],SA_RDY[118],SA_RDY[117],SA_RDY[116],SA_RDY[115],SA_RDY[114],SA_RDY[113],SA_RDY[112],SA_RDY[111],SA_RDY[110],SA_RDY[109],SA_RDY[108],SA_RDY[107],SA_RDY[106],SA_RDY[105],SA_RDY[104],SA_RDY[103],SA_RDY[102],SA_RDY[101],SA_RDY[100],SA_RDY[99],SA_RDY[98],SA_RDY[97],SA_RDY[96],SA_RDY[95],SA_RDY[94],SA_RDY[93],SA_RDY[92],SA_RDY[91],SA_RDY[90],SA_RDY[89],SA_RDY[88],SA_RDY[87],SA_RDY[86],SA_RDY[85],SA_RDY[84],SA_RDY[83],SA_RDY[82],SA_RDY[81],SA_RDY[80],SA_RDY[79],SA_RDY[78],SA_RDY[77],SA_RDY[76],SA_RDY[75],SA_RDY[74],SA_RDY[73],SA_RDY[72],SA_RDY[71],SA_RDY[70],SA_RDY[69],SA_RDY[68],SA_RDY[67],SA_RDY[66],SA_RDY[65],SA_RDY[64],SA_RDY[63],SA_RDY[62],SA_RDY[61],SA_RDY[60],SA_RDY[59],SA_RDY[58],SA_RDY[57],SA_RDY[56],SA_RDY[55],SA_RDY[54],SA_RDY[53],SA_RDY[52],SA_RDY[51],SA_RDY[50],SA_RDY[49],SA_RDY[48],SA_RDY[47],SA_RDY[46],SA_RDY[45],SA_RDY[44],SA_RDY[43],SA_RDY[42],SA_RDY[41],SA_RDY[40],SA_RDY[39],SA_RDY[38],SA_RDY[37],SA_RDY[36],SA_RDY[35],SA_RDY[34],SA_RDY[33],SA_RDY[32],SA_RDY[31],SA_RDY[30],SA_RDY[29],SA_RDY[28],SA_RDY[27],SA_RDY[26],SA_RDY[25],SA_RDY[24],SA_RDY[23],SA_RDY[22],SA_RDY[21],SA_RDY[20],SA_RDY[19],SA_RDY[18],SA_RDY[17],SA_RDY[16],SA_RDY[15],SA_RDY[14],SA_RDY[13],SA_RDY[12],SA_RDY[11],SA_RDY[10],SA_RDY[9],SA_RDY[8],SA_RDY[7],SA_RDY[6],SA_RDY[5],SA_RDY[4],SA_RDY[3],SA_RDY[2],SA_RDY[1],SA_RDY[0]
*.opin
*+ SA_DO[143],SA_DO[142],SA_DO[141],SA_DO[140],SA_DO[139],SA_DO[138],SA_DO[137],SA_DO[136],SA_DO[135],SA_DO[134],SA_DO[133],SA_DO[132],SA_DO[131],SA_DO[130],SA_DO[129],SA_DO[128],SA_DO[127],SA_DO[126],SA_DO[125],SA_DO[124],SA_DO[123],SA_DO[122],SA_DO[121],SA_DO[120],SA_DO[119],SA_DO[118],SA_DO[117],SA_DO[116],SA_DO[115],SA_DO[114],SA_DO[113],SA_DO[112],SA_DO[111],SA_DO[110],SA_DO[109],SA_DO[108],SA_DO[107],SA_DO[106],SA_DO[105],SA_DO[104],SA_DO[103],SA_DO[102],SA_DO[101],SA_DO[100],SA_DO[99],SA_DO[98],SA_DO[97],SA_DO[96],SA_DO[95],SA_DO[94],SA_DO[93],SA_DO[92],SA_DO[91],SA_DO[90],SA_DO[89],SA_DO[88],SA_DO[87],SA_DO[86],SA_DO[85],SA_DO[84],SA_DO[83],SA_DO[82],SA_DO[81],SA_DO[80],SA_DO[79],SA_DO[78],SA_DO[77],SA_DO[76],SA_DO[75],SA_DO[74],SA_DO[73],SA_DO[72],SA_DO[71],SA_DO[70],SA_DO[69],SA_DO[68],SA_DO[67],SA_DO[66],SA_DO[65],SA_DO[64],SA_DO[63],SA_DO[62],SA_DO[61],SA_DO[60],SA_DO[59],SA_DO[58],SA_DO[57],SA_DO[56],SA_DO[55],SA_DO[54],SA_DO[53],SA_DO[52],SA_DO[51],SA_DO[50],SA_DO[49],SA_DO[48],SA_DO[47],SA_DO[46],SA_DO[45],SA_DO[44],SA_DO[43],SA_DO[42],SA_DO[41],SA_DO[40],SA_DO[39],SA_DO[38],SA_DO[37],SA_DO[36],SA_DO[35],SA_DO[34],SA_DO[33],SA_DO[32],SA_DO[31],SA_DO[30],SA_DO[29],SA_DO[28],SA_DO[27],SA_DO[26],SA_DO[25],SA_DO[24],SA_DO[23],SA_DO[22],SA_DO[21],SA_DO[20],SA_DO[19],SA_DO[18],SA_DO[17],SA_DO[16],SA_DO[15],SA_DO[14],SA_DO[13],SA_DO[12],SA_DO[11],SA_DO[10],SA_DO[9],SA_DO[8],SA_DO[7],SA_DO[6],SA_DO[5],SA_DO[4],SA_DO[3],SA_DO[2],SA_DO[1],SA_DO[0]
*.ipin READ_MODE
*.ipin READ_REF[6],READ_REF[5],READ_REF[4],READ_REF[3],READ_REF[2],READ_REF[1],READ_REF[0]
*.ipin REF_MODE
*.ipin RESET_REF[6],RESET_REF[5],RESET_REF[4],RESET_REF[3],RESET_REF[2],RESET_REF[1],RESET_REF[0]
*.ipin SA_CLK
*.ipin SA_EN
*.ipin SET_REF[6],SET_REF[5],SET_REF[4],SET_REF[3],SET_REF[2],SET_REF[1],SET_REF[0]
*.opin
*+ READ_SLICE_ARRAY_ENB_PRE_5[8],READ_SLICE_ARRAY_ENB_PRE_5[7],READ_SLICE_ARRAY_ENB_PRE_5[6],READ_SLICE_ARRAY_ENB_PRE_5[5],READ_SLICE_ARRAY_ENB_PRE_5[4],READ_SLICE_ARRAY_ENB_PRE_5[3],READ_SLICE_ARRAY_ENB_PRE_5[2],READ_SLICE_ARRAY_ENB_PRE_5[1],READ_SLICE_ARRAY_ENB_PRE_5[0]
*.opin
*+ READ_SLICE_COL_ADDR3B_PRE_5[8],READ_SLICE_COL_ADDR3B_PRE_5[7],READ_SLICE_COL_ADDR3B_PRE_5[6],READ_SLICE_COL_ADDR3B_PRE_5[5],READ_SLICE_COL_ADDR3B_PRE_5[4],READ_SLICE_COL_ADDR3B_PRE_5[3],READ_SLICE_COL_ADDR3B_PRE_5[2],READ_SLICE_COL_ADDR3B_PRE_5[1],READ_SLICE_COL_ADDR3B_PRE_5[0]
*.opin
*+ READ_SLICE_DI1_BUF[8],READ_SLICE_DI1_BUF[7],READ_SLICE_DI1_BUF[6],READ_SLICE_DI1_BUF[5],READ_SLICE_DI1_BUF[4],READ_SLICE_DI1_BUF[3],READ_SLICE_DI1_BUF[2],READ_SLICE_DI1_BUF[1],READ_SLICE_DI1_BUF[0]
*.opin
*+ READ_SLICE_READ_REF4_BUF[8],READ_SLICE_READ_REF4_BUF[7],READ_SLICE_READ_REF4_BUF[6],READ_SLICE_READ_REF4_BUF[5],READ_SLICE_READ_REF4_BUF[4],READ_SLICE_READ_REF4_BUF[3],READ_SLICE_READ_REF4_BUF[2],READ_SLICE_READ_REF4_BUF[1],READ_SLICE_READ_REF4_BUF[0]
*.opin
*+ READ_ROUT0_BLOCK_SA_EN_5[8],READ_ROUT0_BLOCK_SA_EN_5[7],READ_ROUT0_BLOCK_SA_EN_5[6],READ_ROUT0_BLOCK_SA_EN_5[5],READ_ROUT0_BLOCK_SA_EN_5[4],READ_ROUT0_BLOCK_SA_EN_5[3],READ_ROUT0_BLOCK_SA_EN_5[2],READ_ROUT0_BLOCK_SA_EN_5[1],READ_ROUT0_BLOCK_SA_EN_5[0]
*.opin
*+ READ_ROUT0_BL_EN_5[8],READ_ROUT0_BL_EN_5[7],READ_ROUT0_BL_EN_5[6],READ_ROUT0_BL_EN_5[5],READ_ROUT0_BL_EN_5[4],READ_ROUT0_BL_EN_5[3],READ_ROUT0_BL_EN_5[2],READ_ROUT0_BL_EN_5[1],READ_ROUT0_BL_EN_5[0]
*.opin
*+ READ_ROUT0_BLOCK_SA_EN[8],READ_ROUT0_BLOCK_SA_EN[7],READ_ROUT0_BLOCK_SA_EN[6],READ_ROUT0_BLOCK_SA_EN[5],READ_ROUT0_BLOCK_SA_EN[4],READ_ROUT0_BLOCK_SA_EN[3],READ_ROUT0_BLOCK_SA_EN[2],READ_ROUT0_BLOCK_SA_EN[1],READ_ROUT0_BLOCK_SA_EN[0]
*.opin
*+ READ_ROUT0_COL_SELECT0_5[8],READ_ROUT0_COL_SELECT0_5[7],READ_ROUT0_COL_SELECT0_5[6],READ_ROUT0_COL_SELECT0_5[5],READ_ROUT0_COL_SELECT0_5[4],READ_ROUT0_COL_SELECT0_5[3],READ_ROUT0_COL_SELECT0_5[2],READ_ROUT0_COL_SELECT0_5[1],READ_ROUT0_COL_SELECT0_5[0]
*.opin
*+ READ_SLICE_REF_MODE_BUF[8],READ_SLICE_REF_MODE_BUF[7],READ_SLICE_REF_MODE_BUF[6],READ_SLICE_REF_MODE_BUF[5],READ_SLICE_REF_MODE_BUF[4],READ_SLICE_REF_MODE_BUF[3],READ_SLICE_REF_MODE_BUF[2],READ_SLICE_REF_MODE_BUF[1],READ_SLICE_REF_MODE_BUF[0]
*.opin
*+ READ_SLICE_RESET_REF4_BUF[8],READ_SLICE_RESET_REF4_BUF[7],READ_SLICE_RESET_REF4_BUF[6],READ_SLICE_RESET_REF4_BUF[5],READ_SLICE_RESET_REF4_BUF[4],READ_SLICE_RESET_REF4_BUF[3],READ_SLICE_RESET_REF4_BUF[2],READ_SLICE_RESET_REF4_BUF[1],READ_SLICE_RESET_REF4_BUF[0]
*.opin
*+ READ_ROUT15_SA_CLK_BUF[8],READ_ROUT15_SA_CLK_BUF[7],READ_ROUT15_SA_CLK_BUF[6],READ_ROUT15_SA_CLK_BUF[5],READ_ROUT15_SA_CLK_BUF[4],READ_ROUT15_SA_CLK_BUF[3],READ_ROUT15_SA_CLK_BUF[2],READ_ROUT15_SA_CLK_BUF[1],READ_ROUT15_SA_CLK_BUF[0]
*.opin
*+ READ_SLICE_SA_CLK_PRE[8],READ_SLICE_SA_CLK_PRE[7],READ_SLICE_SA_CLK_PRE[6],READ_SLICE_SA_CLK_PRE[5],READ_SLICE_SA_CLK_PRE[4],READ_SLICE_SA_CLK_PRE[3],READ_SLICE_SA_CLK_PRE[2],READ_SLICE_SA_CLK_PRE[1],READ_SLICE_SA_CLK_PRE[0]
*.opin
*+ READ_SLICE_SA_EN_PRE[8],READ_SLICE_SA_EN_PRE[7],READ_SLICE_SA_EN_PRE[6],READ_SLICE_SA_EN_PRE[5],READ_SLICE_SA_EN_PRE[4],READ_SLICE_SA_EN_PRE[3],READ_SLICE_SA_EN_PRE[2],READ_SLICE_SA_EN_PRE[1],READ_SLICE_SA_EN_PRE[0]
*.opin
*+ READ_SLICE_SET_REF4_BUF[8],READ_SLICE_SET_REF4_BUF[7],READ_SLICE_SET_REF4_BUF[6],READ_SLICE_SET_REF4_BUF[5],READ_SLICE_SET_REF4_BUF[4],READ_SLICE_SET_REF4_BUF[3],READ_SLICE_SET_REF4_BUF[2],READ_SLICE_SET_REF4_BUF[1],READ_SLICE_SET_REF4_BUF[0]
*.opin
*+ READ_SLICE_SLICE_SELECTB_PRE_5[8],READ_SLICE_SLICE_SELECTB_PRE_5[7],READ_SLICE_SLICE_SELECTB_PRE_5[6],READ_SLICE_SLICE_SELECTB_PRE_5[5],READ_SLICE_SLICE_SELECTB_PRE_5[4],READ_SLICE_SLICE_SELECTB_PRE_5[3],READ_SLICE_SLICE_SELECTB_PRE_5[2],READ_SLICE_SLICE_SELECTB_PRE_5[1],READ_SLICE_SLICE_SELECTB_PRE_5[0]
*.opin
*+ READ_SLICE_SLICE_SELECT_PRE[8],READ_SLICE_SLICE_SELECT_PRE[7],READ_SLICE_SLICE_SELECT_PRE[6],READ_SLICE_SLICE_SELECT_PRE[5],READ_SLICE_SLICE_SELECT_PRE[4],READ_SLICE_SLICE_SELECT_PRE[3],READ_SLICE_SLICE_SELECT_PRE[2],READ_SLICE_SLICE_SELECT_PRE[1],READ_SLICE_SLICE_SELECT_PRE[0]
*.opin
*+ READ_SLICE_WEB_PRE_5[8],READ_SLICE_WEB_PRE_5[7],READ_SLICE_WEB_PRE_5[6],READ_SLICE_WEB_PRE_5[5],READ_SLICE_WEB_PRE_5[4],READ_SLICE_WEB_PRE_5[3],READ_SLICE_WEB_PRE_5[2],READ_SLICE_WEB_PRE_5[1],READ_SLICE_WEB_PRE_5[0]
*.opin
*+ READ_ROUT15_WE_5_BUF[8],READ_ROUT15_WE_5_BUF[7],READ_ROUT15_WE_5_BUF[6],READ_ROUT15_WE_5_BUF[5],READ_ROUT15_WE_5_BUF[4],READ_ROUT15_WE_5_BUF[3],READ_ROUT15_WE_5_BUF[2],READ_ROUT15_WE_5_BUF[1],READ_ROUT15_WE_5_BUF[0]
*.opin COL_ADDR_BAR_5[0]
*.opin WE_5
*.opin ARRAY_EN_BAR_5
*.opin SLICE_SELECT_BAR_5[8]
*.opin SLICE_SELECT[8]
*.opin READ_DI0
*.opin READ_SET_REF[1]
*.opin READ_RESET_REF[0]
*.opin READ_READ_REF[0]
*.opin READ_READ_MODE
*.opin READ_SA_CLK
*.opin READ_REF_MODE
x1[8] READ_READ_MODE SLICE_SELECT_BAR_5[8] READ_ROUT0_COL_SELECT0_5[8] VDD VBL_READ SA_RDY[143]
+ SA_RDY[142] SA_RDY[141] SA_RDY[140] SA_RDY[139] SA_RDY[138] SA_RDY[137] SA_RDY[136] SA_RDY[135] SA_RDY[134]
+ SA_RDY[133] SA_RDY[132] SA_RDY[131] SA_RDY[130] SA_RDY[129] SA_RDY[128] SA_DO[143] SA_DO[142] SA_DO[141]
+ SA_DO[140] SA_DO[139] SA_DO[138] SA_DO[137] SA_DO[136] SA_DO[135] SA_DO[134] SA_DO[133] SA_DO[132] SA_DO[131]
+ SA_DO[130] SA_DO[129] SA_DO[128] SLICE_SELECT[8] BL[2303] BL[2302] BL[2301] BL[2300] BL[2299] BL[2298]
+ BL[2297] BL[2296] BL[2295] BL[2294] BL[2293] BL[2292] BL[2291] BL[2290] BL[2289] BL[2288] BL[2287] BL[2286]
+ BL[2285] BL[2284] BL[2283] BL[2282] BL[2281] BL[2280] BL[2279] BL[2278] BL[2277] BL[2276] BL[2275] BL[2274]
+ BL[2273] BL[2272] BL[2271] BL[2270] BL[2269] BL[2268] BL[2267] BL[2266] BL[2265] BL[2264] BL[2263] BL[2262]
+ BL[2261] BL[2260] BL[2259] BL[2258] BL[2257] BL[2256] BL[2255] BL[2254] BL[2253] BL[2252] BL[2251] BL[2250]
+ BL[2249] BL[2248] BL[2247] BL[2246] BL[2245] BL[2244] BL[2243] BL[2242] BL[2241] BL[2240] BL[2239] BL[2238]
+ BL[2237] BL[2236] BL[2235] BL[2234] BL[2233] BL[2232] BL[2231] BL[2230] BL[2229] BL[2228] BL[2227] BL[2226]
+ BL[2225] BL[2224] BL[2223] BL[2222] BL[2221] BL[2220] BL[2219] BL[2218] BL[2217] BL[2216] BL[2215] BL[2214]
+ BL[2213] BL[2212] BL[2211] BL[2210] BL[2209] BL[2208] BL[2207] BL[2206] BL[2205] BL[2204] BL[2203] BL[2202]
+ BL[2201] BL[2200] BL[2199] BL[2198] BL[2197] BL[2196] BL[2195] BL[2194] BL[2193] BL[2192] BL[2191] BL[2190]
+ BL[2189] BL[2188] BL[2187] BL[2186] BL[2185] BL[2184] BL[2183] BL[2182] BL[2181] BL[2180] BL[2179] BL[2178]
+ BL[2177] BL[2176] BL[2175] BL[2174] BL[2173] BL[2172] BL[2171] BL[2170] BL[2169] BL[2168] BL[2167] BL[2166]
+ BL[2165] BL[2164] BL[2163] BL[2162] BL[2161] BL[2160] BL[2159] BL[2158] BL[2157] BL[2156] BL[2155] BL[2154]
+ BL[2153] BL[2152] BL[2151] BL[2150] BL[2149] BL[2148] BL[2147] BL[2146] BL[2145] BL[2144] BL[2143] BL[2142]
+ BL[2141] BL[2140] BL[2139] BL[2138] BL[2137] BL[2136] BL[2135] BL[2134] BL[2133] BL[2132] BL[2131] BL[2130]
+ BL[2129] BL[2128] BL[2127] BL[2126] BL[2125] BL[2124] BL[2123] BL[2122] BL[2121] BL[2120] BL[2119] BL[2118]
+ BL[2117] BL[2116] BL[2115] BL[2114] BL[2113] BL[2112] BL[2111] BL[2110] BL[2109] BL[2108] BL[2107] BL[2106]
+ BL[2105] BL[2104] BL[2103] BL[2102] BL[2101] BL[2100] BL[2099] BL[2098] BL[2097] BL[2096] BL[2095] BL[2094]
+ BL[2093] BL[2092] BL[2091] BL[2090] BL[2089] BL[2088] BL[2087] BL[2086] BL[2085] BL[2084] BL[2083] BL[2082]
+ BL[2081] BL[2080] BL[2079] BL[2078] BL[2077] BL[2076] BL[2075] BL[2074] BL[2073] BL[2072] BL[2071] BL[2070]
+ BL[2069] BL[2068] BL[2067] BL[2066] BL[2065] BL[2064] BL[2063] BL[2062] BL[2061] BL[2060] BL[2059] BL[2058]
+ BL[2057] BL[2056] BL[2055] BL[2054] BL[2053] BL[2052] BL[2051] BL[2050] BL[2049] BL[2048] VSS READ_REF[6]
+ READ_REF[5] READ_REF[4] READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[8]
+ READ_ROUT0_BL_EN_5[8] DI[15] DI[14] DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1]
+ READ_DI0 READ_REF_MODE AVDD READ_ROUT0_BLOCK_SA_EN[8] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4]
+ RESET_REF[3] RESET_REF[2] RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1]
+ COL_ADDR_BAR_5[0] AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[8] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[8] SET_REF[6]
+ SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[8]
+ READ_SLICE_SLICE_SELECT_PRE[8] READ_SLICE_SA_EN_PRE[8] READ_SLICE_SA_CLK_PRE[8] READ_SLICE_COL_ADDR3B_PRE_5[8]
+ READ_SLICE_ARRAY_ENB_PRE_5[8] READ_SLICE_READ_REF4_BUF[8] READ_SLICE_REF_MODE_BUF[8] READ_SLICE_RESET_REF4_BUF[8]
+ READ_SLICE_SET_REF4_BUF[8] READ_SLICE_DI1_BUF[8] READ_SLICE_WEB_PRE_5[8] readout_slice
x1[7] READ_READ_MODE SLICE_SELECT_BAR_5[7] READ_ROUT0_COL_SELECT0_5[7] VDD VBL_READ SA_RDY[127]
+ SA_RDY[126] SA_RDY[125] SA_RDY[124] SA_RDY[123] SA_RDY[122] SA_RDY[121] SA_RDY[120] SA_RDY[119] SA_RDY[118]
+ SA_RDY[117] SA_RDY[116] SA_RDY[115] SA_RDY[114] SA_RDY[113] SA_RDY[112] SA_DO[127] SA_DO[126] SA_DO[125]
+ SA_DO[124] SA_DO[123] SA_DO[122] SA_DO[121] SA_DO[120] SA_DO[119] SA_DO[118] SA_DO[117] SA_DO[116] SA_DO[115]
+ SA_DO[114] SA_DO[113] SA_DO[112] SLICE_SELECT[7] BL[2047] BL[2046] BL[2045] BL[2044] BL[2043] BL[2042]
+ BL[2041] BL[2040] BL[2039] BL[2038] BL[2037] BL[2036] BL[2035] BL[2034] BL[2033] BL[2032] BL[2031] BL[2030]
+ BL[2029] BL[2028] BL[2027] BL[2026] BL[2025] BL[2024] BL[2023] BL[2022] BL[2021] BL[2020] BL[2019] BL[2018]
+ BL[2017] BL[2016] BL[2015] BL[2014] BL[2013] BL[2012] BL[2011] BL[2010] BL[2009] BL[2008] BL[2007] BL[2006]
+ BL[2005] BL[2004] BL[2003] BL[2002] BL[2001] BL[2000] BL[1999] BL[1998] BL[1997] BL[1996] BL[1995] BL[1994]
+ BL[1993] BL[1992] BL[1991] BL[1990] BL[1989] BL[1988] BL[1987] BL[1986] BL[1985] BL[1984] BL[1983] BL[1982]
+ BL[1981] BL[1980] BL[1979] BL[1978] BL[1977] BL[1976] BL[1975] BL[1974] BL[1973] BL[1972] BL[1971] BL[1970]
+ BL[1969] BL[1968] BL[1967] BL[1966] BL[1965] BL[1964] BL[1963] BL[1962] BL[1961] BL[1960] BL[1959] BL[1958]
+ BL[1957] BL[1956] BL[1955] BL[1954] BL[1953] BL[1952] BL[1951] BL[1950] BL[1949] BL[1948] BL[1947] BL[1946]
+ BL[1945] BL[1944] BL[1943] BL[1942] BL[1941] BL[1940] BL[1939] BL[1938] BL[1937] BL[1936] BL[1935] BL[1934]
+ BL[1933] BL[1932] BL[1931] BL[1930] BL[1929] BL[1928] BL[1927] BL[1926] BL[1925] BL[1924] BL[1923] BL[1922]
+ BL[1921] BL[1920] BL[1919] BL[1918] BL[1917] BL[1916] BL[1915] BL[1914] BL[1913] BL[1912] BL[1911] BL[1910]
+ BL[1909] BL[1908] BL[1907] BL[1906] BL[1905] BL[1904] BL[1903] BL[1902] BL[1901] BL[1900] BL[1899] BL[1898]
+ BL[1897] BL[1896] BL[1895] BL[1894] BL[1893] BL[1892] BL[1891] BL[1890] BL[1889] BL[1888] BL[1887] BL[1886]
+ BL[1885] BL[1884] BL[1883] BL[1882] BL[1881] BL[1880] BL[1879] BL[1878] BL[1877] BL[1876] BL[1875] BL[1874]
+ BL[1873] BL[1872] BL[1871] BL[1870] BL[1869] BL[1868] BL[1867] BL[1866] BL[1865] BL[1864] BL[1863] BL[1862]
+ BL[1861] BL[1860] BL[1859] BL[1858] BL[1857] BL[1856] BL[1855] BL[1854] BL[1853] BL[1852] BL[1851] BL[1850]
+ BL[1849] BL[1848] BL[1847] BL[1846] BL[1845] BL[1844] BL[1843] BL[1842] BL[1841] BL[1840] BL[1839] BL[1838]
+ BL[1837] BL[1836] BL[1835] BL[1834] BL[1833] BL[1832] BL[1831] BL[1830] BL[1829] BL[1828] BL[1827] BL[1826]
+ BL[1825] BL[1824] BL[1823] BL[1822] BL[1821] BL[1820] BL[1819] BL[1818] BL[1817] BL[1816] BL[1815] BL[1814]
+ BL[1813] BL[1812] BL[1811] BL[1810] BL[1809] BL[1808] BL[1807] BL[1806] BL[1805] BL[1804] BL[1803] BL[1802]
+ BL[1801] BL[1800] BL[1799] BL[1798] BL[1797] BL[1796] BL[1795] BL[1794] BL[1793] BL[1792] VSS READ_REF[6]
+ READ_REF[5] READ_REF[4] READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[7]
+ READ_ROUT0_BL_EN_5[7] DI[15] DI[14] DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1]
+ READ_DI0 READ_REF_MODE AVDD READ_ROUT0_BLOCK_SA_EN[7] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4]
+ RESET_REF[3] RESET_REF[2] RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1]
+ COL_ADDR_BAR_5[0] AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[7] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[7] SET_REF[6]
+ SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[7]
+ READ_SLICE_SLICE_SELECT_PRE[7] READ_SLICE_SA_EN_PRE[7] READ_SLICE_SA_CLK_PRE[7] READ_SLICE_COL_ADDR3B_PRE_5[7]
+ READ_SLICE_ARRAY_ENB_PRE_5[7] READ_SLICE_READ_REF4_BUF[7] READ_SLICE_REF_MODE_BUF[7] READ_SLICE_RESET_REF4_BUF[7]
+ READ_SLICE_SET_REF4_BUF[7] READ_SLICE_DI1_BUF[7] READ_SLICE_WEB_PRE_5[7] readout_slice
x1[6] READ_READ_MODE SLICE_SELECT_BAR_5[6] READ_ROUT0_COL_SELECT0_5[6] VDD VBL_READ SA_RDY[111]
+ SA_RDY[110] SA_RDY[109] SA_RDY[108] SA_RDY[107] SA_RDY[106] SA_RDY[105] SA_RDY[104] SA_RDY[103] SA_RDY[102]
+ SA_RDY[101] SA_RDY[100] SA_RDY[99] SA_RDY[98] SA_RDY[97] SA_RDY[96] SA_DO[111] SA_DO[110] SA_DO[109] SA_DO[108]
+ SA_DO[107] SA_DO[106] SA_DO[105] SA_DO[104] SA_DO[103] SA_DO[102] SA_DO[101] SA_DO[100] SA_DO[99] SA_DO[98]
+ SA_DO[97] SA_DO[96] SLICE_SELECT[6] BL[1791] BL[1790] BL[1789] BL[1788] BL[1787] BL[1786] BL[1785] BL[1784]
+ BL[1783] BL[1782] BL[1781] BL[1780] BL[1779] BL[1778] BL[1777] BL[1776] BL[1775] BL[1774] BL[1773] BL[1772]
+ BL[1771] BL[1770] BL[1769] BL[1768] BL[1767] BL[1766] BL[1765] BL[1764] BL[1763] BL[1762] BL[1761] BL[1760]
+ BL[1759] BL[1758] BL[1757] BL[1756] BL[1755] BL[1754] BL[1753] BL[1752] BL[1751] BL[1750] BL[1749] BL[1748]
+ BL[1747] BL[1746] BL[1745] BL[1744] BL[1743] BL[1742] BL[1741] BL[1740] BL[1739] BL[1738] BL[1737] BL[1736]
+ BL[1735] BL[1734] BL[1733] BL[1732] BL[1731] BL[1730] BL[1729] BL[1728] BL[1727] BL[1726] BL[1725] BL[1724]
+ BL[1723] BL[1722] BL[1721] BL[1720] BL[1719] BL[1718] BL[1717] BL[1716] BL[1715] BL[1714] BL[1713] BL[1712]
+ BL[1711] BL[1710] BL[1709] BL[1708] BL[1707] BL[1706] BL[1705] BL[1704] BL[1703] BL[1702] BL[1701] BL[1700]
+ BL[1699] BL[1698] BL[1697] BL[1696] BL[1695] BL[1694] BL[1693] BL[1692] BL[1691] BL[1690] BL[1689] BL[1688]
+ BL[1687] BL[1686] BL[1685] BL[1684] BL[1683] BL[1682] BL[1681] BL[1680] BL[1679] BL[1678] BL[1677] BL[1676]
+ BL[1675] BL[1674] BL[1673] BL[1672] BL[1671] BL[1670] BL[1669] BL[1668] BL[1667] BL[1666] BL[1665] BL[1664]
+ BL[1663] BL[1662] BL[1661] BL[1660] BL[1659] BL[1658] BL[1657] BL[1656] BL[1655] BL[1654] BL[1653] BL[1652]
+ BL[1651] BL[1650] BL[1649] BL[1648] BL[1647] BL[1646] BL[1645] BL[1644] BL[1643] BL[1642] BL[1641] BL[1640]
+ BL[1639] BL[1638] BL[1637] BL[1636] BL[1635] BL[1634] BL[1633] BL[1632] BL[1631] BL[1630] BL[1629] BL[1628]
+ BL[1627] BL[1626] BL[1625] BL[1624] BL[1623] BL[1622] BL[1621] BL[1620] BL[1619] BL[1618] BL[1617] BL[1616]
+ BL[1615] BL[1614] BL[1613] BL[1612] BL[1611] BL[1610] BL[1609] BL[1608] BL[1607] BL[1606] BL[1605] BL[1604]
+ BL[1603] BL[1602] BL[1601] BL[1600] BL[1599] BL[1598] BL[1597] BL[1596] BL[1595] BL[1594] BL[1593] BL[1592]
+ BL[1591] BL[1590] BL[1589] BL[1588] BL[1587] BL[1586] BL[1585] BL[1584] BL[1583] BL[1582] BL[1581] BL[1580]
+ BL[1579] BL[1578] BL[1577] BL[1576] BL[1575] BL[1574] BL[1573] BL[1572] BL[1571] BL[1570] BL[1569] BL[1568]
+ BL[1567] BL[1566] BL[1565] BL[1564] BL[1563] BL[1562] BL[1561] BL[1560] BL[1559] BL[1558] BL[1557] BL[1556]
+ BL[1555] BL[1554] BL[1553] BL[1552] BL[1551] BL[1550] BL[1549] BL[1548] BL[1547] BL[1546] BL[1545] BL[1544]
+ BL[1543] BL[1542] BL[1541] BL[1540] BL[1539] BL[1538] BL[1537] BL[1536] VSS READ_REF[6] READ_REF[5]
+ READ_REF[4] READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[6] READ_ROUT0_BL_EN_5[6]
+ DI[15] DI[14] DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1] READ_DI0
+ READ_REF_MODE AVDD READ_ROUT0_BLOCK_SA_EN[6] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4] RESET_REF[3]
+ RESET_REF[2] RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1] COL_ADDR_BAR_5[0]
+ AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[6] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[6] SET_REF[6]
+ SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[6]
+ READ_SLICE_SLICE_SELECT_PRE[6] READ_SLICE_SA_EN_PRE[6] READ_SLICE_SA_CLK_PRE[6] READ_SLICE_COL_ADDR3B_PRE_5[6]
+ READ_SLICE_ARRAY_ENB_PRE_5[6] READ_SLICE_READ_REF4_BUF[6] READ_SLICE_REF_MODE_BUF[6] READ_SLICE_RESET_REF4_BUF[6]
+ READ_SLICE_SET_REF4_BUF[6] READ_SLICE_DI1_BUF[6] READ_SLICE_WEB_PRE_5[6] readout_slice
x1[5] READ_READ_MODE SLICE_SELECT_BAR_5[5] READ_ROUT0_COL_SELECT0_5[5] VDD VBL_READ SA_RDY[95]
+ SA_RDY[94] SA_RDY[93] SA_RDY[92] SA_RDY[91] SA_RDY[90] SA_RDY[89] SA_RDY[88] SA_RDY[87] SA_RDY[86] SA_RDY[85]
+ SA_RDY[84] SA_RDY[83] SA_RDY[82] SA_RDY[81] SA_RDY[80] SA_DO[95] SA_DO[94] SA_DO[93] SA_DO[92] SA_DO[91]
+ SA_DO[90] SA_DO[89] SA_DO[88] SA_DO[87] SA_DO[86] SA_DO[85] SA_DO[84] SA_DO[83] SA_DO[82] SA_DO[81] SA_DO[80]
+ SLICE_SELECT[5] BL[1535] BL[1534] BL[1533] BL[1532] BL[1531] BL[1530] BL[1529] BL[1528] BL[1527] BL[1526] BL[1525]
+ BL[1524] BL[1523] BL[1522] BL[1521] BL[1520] BL[1519] BL[1518] BL[1517] BL[1516] BL[1515] BL[1514] BL[1513]
+ BL[1512] BL[1511] BL[1510] BL[1509] BL[1508] BL[1507] BL[1506] BL[1505] BL[1504] BL[1503] BL[1502] BL[1501]
+ BL[1500] BL[1499] BL[1498] BL[1497] BL[1496] BL[1495] BL[1494] BL[1493] BL[1492] BL[1491] BL[1490] BL[1489]
+ BL[1488] BL[1487] BL[1486] BL[1485] BL[1484] BL[1483] BL[1482] BL[1481] BL[1480] BL[1479] BL[1478] BL[1477]
+ BL[1476] BL[1475] BL[1474] BL[1473] BL[1472] BL[1471] BL[1470] BL[1469] BL[1468] BL[1467] BL[1466] BL[1465]
+ BL[1464] BL[1463] BL[1462] BL[1461] BL[1460] BL[1459] BL[1458] BL[1457] BL[1456] BL[1455] BL[1454] BL[1453]
+ BL[1452] BL[1451] BL[1450] BL[1449] BL[1448] BL[1447] BL[1446] BL[1445] BL[1444] BL[1443] BL[1442] BL[1441]
+ BL[1440] BL[1439] BL[1438] BL[1437] BL[1436] BL[1435] BL[1434] BL[1433] BL[1432] BL[1431] BL[1430] BL[1429]
+ BL[1428] BL[1427] BL[1426] BL[1425] BL[1424] BL[1423] BL[1422] BL[1421] BL[1420] BL[1419] BL[1418] BL[1417]
+ BL[1416] BL[1415] BL[1414] BL[1413] BL[1412] BL[1411] BL[1410] BL[1409] BL[1408] BL[1407] BL[1406] BL[1405]
+ BL[1404] BL[1403] BL[1402] BL[1401] BL[1400] BL[1399] BL[1398] BL[1397] BL[1396] BL[1395] BL[1394] BL[1393]
+ BL[1392] BL[1391] BL[1390] BL[1389] BL[1388] BL[1387] BL[1386] BL[1385] BL[1384] BL[1383] BL[1382] BL[1381]
+ BL[1380] BL[1379] BL[1378] BL[1377] BL[1376] BL[1375] BL[1374] BL[1373] BL[1372] BL[1371] BL[1370] BL[1369]
+ BL[1368] BL[1367] BL[1366] BL[1365] BL[1364] BL[1363] BL[1362] BL[1361] BL[1360] BL[1359] BL[1358] BL[1357]
+ BL[1356] BL[1355] BL[1354] BL[1353] BL[1352] BL[1351] BL[1350] BL[1349] BL[1348] BL[1347] BL[1346] BL[1345]
+ BL[1344] BL[1343] BL[1342] BL[1341] BL[1340] BL[1339] BL[1338] BL[1337] BL[1336] BL[1335] BL[1334] BL[1333]
+ BL[1332] BL[1331] BL[1330] BL[1329] BL[1328] BL[1327] BL[1326] BL[1325] BL[1324] BL[1323] BL[1322] BL[1321]
+ BL[1320] BL[1319] BL[1318] BL[1317] BL[1316] BL[1315] BL[1314] BL[1313] BL[1312] BL[1311] BL[1310] BL[1309]
+ BL[1308] BL[1307] BL[1306] BL[1305] BL[1304] BL[1303] BL[1302] BL[1301] BL[1300] BL[1299] BL[1298] BL[1297]
+ BL[1296] BL[1295] BL[1294] BL[1293] BL[1292] BL[1291] BL[1290] BL[1289] BL[1288] BL[1287] BL[1286] BL[1285]
+ BL[1284] BL[1283] BL[1282] BL[1281] BL[1280] VSS READ_REF[6] READ_REF[5] READ_REF[4] READ_REF[3] READ_REF[2]
+ READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[5] READ_ROUT0_BL_EN_5[5] DI[15] DI[14] DI[13] DI[12] DI[11]
+ DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1] READ_DI0 READ_REF_MODE AVDD
+ READ_ROUT0_BLOCK_SA_EN[5] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4] RESET_REF[3] RESET_REF[2] RESET_REF[1] RESET_REF[0]
+ COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1] COL_ADDR_BAR_5[0] AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[5]
+ SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[5] SET_REF[6] SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2]
+ SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[5] READ_SLICE_SLICE_SELECT_PRE[5] READ_SLICE_SA_EN_PRE[5]
+ READ_SLICE_SA_CLK_PRE[5] READ_SLICE_COL_ADDR3B_PRE_5[5] READ_SLICE_ARRAY_ENB_PRE_5[5] READ_SLICE_READ_REF4_BUF[5]
+ READ_SLICE_REF_MODE_BUF[5] READ_SLICE_RESET_REF4_BUF[5] READ_SLICE_SET_REF4_BUF[5] READ_SLICE_DI1_BUF[5]
+ READ_SLICE_WEB_PRE_5[5] readout_slice
x1[4] READ_READ_MODE SLICE_SELECT_BAR_5[4] READ_ROUT0_COL_SELECT0_5[4] VDD VBL_READ SA_RDY[79]
+ SA_RDY[78] SA_RDY[77] SA_RDY[76] SA_RDY[75] SA_RDY[74] SA_RDY[73] SA_RDY[72] SA_RDY[71] SA_RDY[70] SA_RDY[69]
+ SA_RDY[68] SA_RDY[67] SA_RDY[66] SA_RDY[65] SA_RDY[64] SA_DO[79] SA_DO[78] SA_DO[77] SA_DO[76] SA_DO[75]
+ SA_DO[74] SA_DO[73] SA_DO[72] SA_DO[71] SA_DO[70] SA_DO[69] SA_DO[68] SA_DO[67] SA_DO[66] SA_DO[65] SA_DO[64]
+ SLICE_SELECT[4] BL[1279] BL[1278] BL[1277] BL[1276] BL[1275] BL[1274] BL[1273] BL[1272] BL[1271] BL[1270] BL[1269]
+ BL[1268] BL[1267] BL[1266] BL[1265] BL[1264] BL[1263] BL[1262] BL[1261] BL[1260] BL[1259] BL[1258] BL[1257]
+ BL[1256] BL[1255] BL[1254] BL[1253] BL[1252] BL[1251] BL[1250] BL[1249] BL[1248] BL[1247] BL[1246] BL[1245]
+ BL[1244] BL[1243] BL[1242] BL[1241] BL[1240] BL[1239] BL[1238] BL[1237] BL[1236] BL[1235] BL[1234] BL[1233]
+ BL[1232] BL[1231] BL[1230] BL[1229] BL[1228] BL[1227] BL[1226] BL[1225] BL[1224] BL[1223] BL[1222] BL[1221]
+ BL[1220] BL[1219] BL[1218] BL[1217] BL[1216] BL[1215] BL[1214] BL[1213] BL[1212] BL[1211] BL[1210] BL[1209]
+ BL[1208] BL[1207] BL[1206] BL[1205] BL[1204] BL[1203] BL[1202] BL[1201] BL[1200] BL[1199] BL[1198] BL[1197]
+ BL[1196] BL[1195] BL[1194] BL[1193] BL[1192] BL[1191] BL[1190] BL[1189] BL[1188] BL[1187] BL[1186] BL[1185]
+ BL[1184] BL[1183] BL[1182] BL[1181] BL[1180] BL[1179] BL[1178] BL[1177] BL[1176] BL[1175] BL[1174] BL[1173]
+ BL[1172] BL[1171] BL[1170] BL[1169] BL[1168] BL[1167] BL[1166] BL[1165] BL[1164] BL[1163] BL[1162] BL[1161]
+ BL[1160] BL[1159] BL[1158] BL[1157] BL[1156] BL[1155] BL[1154] BL[1153] BL[1152] BL[1151] BL[1150] BL[1149]
+ BL[1148] BL[1147] BL[1146] BL[1145] BL[1144] BL[1143] BL[1142] BL[1141] BL[1140] BL[1139] BL[1138] BL[1137]
+ BL[1136] BL[1135] BL[1134] BL[1133] BL[1132] BL[1131] BL[1130] BL[1129] BL[1128] BL[1127] BL[1126] BL[1125]
+ BL[1124] BL[1123] BL[1122] BL[1121] BL[1120] BL[1119] BL[1118] BL[1117] BL[1116] BL[1115] BL[1114] BL[1113]
+ BL[1112] BL[1111] BL[1110] BL[1109] BL[1108] BL[1107] BL[1106] BL[1105] BL[1104] BL[1103] BL[1102] BL[1101]
+ BL[1100] BL[1099] BL[1098] BL[1097] BL[1096] BL[1095] BL[1094] BL[1093] BL[1092] BL[1091] BL[1090] BL[1089]
+ BL[1088] BL[1087] BL[1086] BL[1085] BL[1084] BL[1083] BL[1082] BL[1081] BL[1080] BL[1079] BL[1078] BL[1077]
+ BL[1076] BL[1075] BL[1074] BL[1073] BL[1072] BL[1071] BL[1070] BL[1069] BL[1068] BL[1067] BL[1066] BL[1065]
+ BL[1064] BL[1063] BL[1062] BL[1061] BL[1060] BL[1059] BL[1058] BL[1057] BL[1056] BL[1055] BL[1054] BL[1053]
+ BL[1052] BL[1051] BL[1050] BL[1049] BL[1048] BL[1047] BL[1046] BL[1045] BL[1044] BL[1043] BL[1042] BL[1041]
+ BL[1040] BL[1039] BL[1038] BL[1037] BL[1036] BL[1035] BL[1034] BL[1033] BL[1032] BL[1031] BL[1030] BL[1029]
+ BL[1028] BL[1027] BL[1026] BL[1025] BL[1024] VSS READ_REF[6] READ_REF[5] READ_REF[4] READ_REF[3] READ_REF[2]
+ READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[4] READ_ROUT0_BL_EN_5[4] DI[15] DI[14] DI[13] DI[12] DI[11]
+ DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1] READ_DI0 READ_REF_MODE AVDD
+ READ_ROUT0_BLOCK_SA_EN[4] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4] RESET_REF[3] RESET_REF[2] RESET_REF[1] RESET_REF[0]
+ COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1] COL_ADDR_BAR_5[0] AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[4]
+ SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[4] SET_REF[6] SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2]
+ SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[4] READ_SLICE_SLICE_SELECT_PRE[4] READ_SLICE_SA_EN_PRE[4]
+ READ_SLICE_SA_CLK_PRE[4] READ_SLICE_COL_ADDR3B_PRE_5[4] READ_SLICE_ARRAY_ENB_PRE_5[4] READ_SLICE_READ_REF4_BUF[4]
+ READ_SLICE_REF_MODE_BUF[4] READ_SLICE_RESET_REF4_BUF[4] READ_SLICE_SET_REF4_BUF[4] READ_SLICE_DI1_BUF[4]
+ READ_SLICE_WEB_PRE_5[4] readout_slice
x1[3] READ_READ_MODE SLICE_SELECT_BAR_5[3] READ_ROUT0_COL_SELECT0_5[3] VDD VBL_READ SA_RDY[63]
+ SA_RDY[62] SA_RDY[61] SA_RDY[60] SA_RDY[59] SA_RDY[58] SA_RDY[57] SA_RDY[56] SA_RDY[55] SA_RDY[54] SA_RDY[53]
+ SA_RDY[52] SA_RDY[51] SA_RDY[50] SA_RDY[49] SA_RDY[48] SA_DO[63] SA_DO[62] SA_DO[61] SA_DO[60] SA_DO[59]
+ SA_DO[58] SA_DO[57] SA_DO[56] SA_DO[55] SA_DO[54] SA_DO[53] SA_DO[52] SA_DO[51] SA_DO[50] SA_DO[49] SA_DO[48]
+ SLICE_SELECT[3] BL[1023] BL[1022] BL[1021] BL[1020] BL[1019] BL[1018] BL[1017] BL[1016] BL[1015] BL[1014] BL[1013]
+ BL[1012] BL[1011] BL[1010] BL[1009] BL[1008] BL[1007] BL[1006] BL[1005] BL[1004] BL[1003] BL[1002] BL[1001]
+ BL[1000] BL[999] BL[998] BL[997] BL[996] BL[995] BL[994] BL[993] BL[992] BL[991] BL[990] BL[989] BL[988]
+ BL[987] BL[986] BL[985] BL[984] BL[983] BL[982] BL[981] BL[980] BL[979] BL[978] BL[977] BL[976] BL[975]
+ BL[974] BL[973] BL[972] BL[971] BL[970] BL[969] BL[968] BL[967] BL[966] BL[965] BL[964] BL[963] BL[962]
+ BL[961] BL[960] BL[959] BL[958] BL[957] BL[956] BL[955] BL[954] BL[953] BL[952] BL[951] BL[950] BL[949]
+ BL[948] BL[947] BL[946] BL[945] BL[944] BL[943] BL[942] BL[941] BL[940] BL[939] BL[938] BL[937] BL[936]
+ BL[935] BL[934] BL[933] BL[932] BL[931] BL[930] BL[929] BL[928] BL[927] BL[926] BL[925] BL[924] BL[923]
+ BL[922] BL[921] BL[920] BL[919] BL[918] BL[917] BL[916] BL[915] BL[914] BL[913] BL[912] BL[911] BL[910]
+ BL[909] BL[908] BL[907] BL[906] BL[905] BL[904] BL[903] BL[902] BL[901] BL[900] BL[899] BL[898] BL[897]
+ BL[896] BL[895] BL[894] BL[893] BL[892] BL[891] BL[890] BL[889] BL[888] BL[887] BL[886] BL[885] BL[884]
+ BL[883] BL[882] BL[881] BL[880] BL[879] BL[878] BL[877] BL[876] BL[875] BL[874] BL[873] BL[872] BL[871]
+ BL[870] BL[869] BL[868] BL[867] BL[866] BL[865] BL[864] BL[863] BL[862] BL[861] BL[860] BL[859] BL[858]
+ BL[857] BL[856] BL[855] BL[854] BL[853] BL[852] BL[851] BL[850] BL[849] BL[848] BL[847] BL[846] BL[845]
+ BL[844] BL[843] BL[842] BL[841] BL[840] BL[839] BL[838] BL[837] BL[836] BL[835] BL[834] BL[833] BL[832]
+ BL[831] BL[830] BL[829] BL[828] BL[827] BL[826] BL[825] BL[824] BL[823] BL[822] BL[821] BL[820] BL[819]
+ BL[818] BL[817] BL[816] BL[815] BL[814] BL[813] BL[812] BL[811] BL[810] BL[809] BL[808] BL[807] BL[806]
+ BL[805] BL[804] BL[803] BL[802] BL[801] BL[800] BL[799] BL[798] BL[797] BL[796] BL[795] BL[794] BL[793]
+ BL[792] BL[791] BL[790] BL[789] BL[788] BL[787] BL[786] BL[785] BL[784] BL[783] BL[782] BL[781] BL[780]
+ BL[779] BL[778] BL[777] BL[776] BL[775] BL[774] BL[773] BL[772] BL[771] BL[770] BL[769] BL[768] VSS
+ READ_REF[6] READ_REF[5] READ_REF[4] READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[3]
+ READ_ROUT0_BL_EN_5[3] DI[15] DI[14] DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1]
+ READ_DI0 READ_REF_MODE AVDD READ_ROUT0_BLOCK_SA_EN[3] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4]
+ RESET_REF[3] RESET_REF[2] RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1]
+ COL_ADDR_BAR_5[0] AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[3] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[3] SET_REF[6]
+ SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[3]
+ READ_SLICE_SLICE_SELECT_PRE[3] READ_SLICE_SA_EN_PRE[3] READ_SLICE_SA_CLK_PRE[3] READ_SLICE_COL_ADDR3B_PRE_5[3]
+ READ_SLICE_ARRAY_ENB_PRE_5[3] READ_SLICE_READ_REF4_BUF[3] READ_SLICE_REF_MODE_BUF[3] READ_SLICE_RESET_REF4_BUF[3]
+ READ_SLICE_SET_REF4_BUF[3] READ_SLICE_DI1_BUF[3] READ_SLICE_WEB_PRE_5[3] readout_slice
x1[2] READ_READ_MODE SLICE_SELECT_BAR_5[2] READ_ROUT0_COL_SELECT0_5[2] VDD VBL_READ SA_RDY[47]
+ SA_RDY[46] SA_RDY[45] SA_RDY[44] SA_RDY[43] SA_RDY[42] SA_RDY[41] SA_RDY[40] SA_RDY[39] SA_RDY[38] SA_RDY[37]
+ SA_RDY[36] SA_RDY[35] SA_RDY[34] SA_RDY[33] SA_RDY[32] SA_DO[47] SA_DO[46] SA_DO[45] SA_DO[44] SA_DO[43]
+ SA_DO[42] SA_DO[41] SA_DO[40] SA_DO[39] SA_DO[38] SA_DO[37] SA_DO[36] SA_DO[35] SA_DO[34] SA_DO[33] SA_DO[32]
+ SLICE_SELECT[2] BL[767] BL[766] BL[765] BL[764] BL[763] BL[762] BL[761] BL[760] BL[759] BL[758] BL[757] BL[756]
+ BL[755] BL[754] BL[753] BL[752] BL[751] BL[750] BL[749] BL[748] BL[747] BL[746] BL[745] BL[744] BL[743]
+ BL[742] BL[741] BL[740] BL[739] BL[738] BL[737] BL[736] BL[735] BL[734] BL[733] BL[732] BL[731] BL[730]
+ BL[729] BL[728] BL[727] BL[726] BL[725] BL[724] BL[723] BL[722] BL[721] BL[720] BL[719] BL[718] BL[717]
+ BL[716] BL[715] BL[714] BL[713] BL[712] BL[711] BL[710] BL[709] BL[708] BL[707] BL[706] BL[705] BL[704]
+ BL[703] BL[702] BL[701] BL[700] BL[699] BL[698] BL[697] BL[696] BL[695] BL[694] BL[693] BL[692] BL[691]
+ BL[690] BL[689] BL[688] BL[687] BL[686] BL[685] BL[684] BL[683] BL[682] BL[681] BL[680] BL[679] BL[678]
+ BL[677] BL[676] BL[675] BL[674] BL[673] BL[672] BL[671] BL[670] BL[669] BL[668] BL[667] BL[666] BL[665]
+ BL[664] BL[663] BL[662] BL[661] BL[660] BL[659] BL[658] BL[657] BL[656] BL[655] BL[654] BL[653] BL[652]
+ BL[651] BL[650] BL[649] BL[648] BL[647] BL[646] BL[645] BL[644] BL[643] BL[642] BL[641] BL[640] BL[639]
+ BL[638] BL[637] BL[636] BL[635] BL[634] BL[633] BL[632] BL[631] BL[630] BL[629] BL[628] BL[627] BL[626]
+ BL[625] BL[624] BL[623] BL[622] BL[621] BL[620] BL[619] BL[618] BL[617] BL[616] BL[615] BL[614] BL[613]
+ BL[612] BL[611] BL[610] BL[609] BL[608] BL[607] BL[606] BL[605] BL[604] BL[603] BL[602] BL[601] BL[600]
+ BL[599] BL[598] BL[597] BL[596] BL[595] BL[594] BL[593] BL[592] BL[591] BL[590] BL[589] BL[588] BL[587]
+ BL[586] BL[585] BL[584] BL[583] BL[582] BL[581] BL[580] BL[579] BL[578] BL[577] BL[576] BL[575] BL[574]
+ BL[573] BL[572] BL[571] BL[570] BL[569] BL[568] BL[567] BL[566] BL[565] BL[564] BL[563] BL[562] BL[561]
+ BL[560] BL[559] BL[558] BL[557] BL[556] BL[555] BL[554] BL[553] BL[552] BL[551] BL[550] BL[549] BL[548]
+ BL[547] BL[546] BL[545] BL[544] BL[543] BL[542] BL[541] BL[540] BL[539] BL[538] BL[537] BL[536] BL[535]
+ BL[534] BL[533] BL[532] BL[531] BL[530] BL[529] BL[528] BL[527] BL[526] BL[525] BL[524] BL[523] BL[522]
+ BL[521] BL[520] BL[519] BL[518] BL[517] BL[516] BL[515] BL[514] BL[513] BL[512] VSS READ_REF[6] READ_REF[5]
+ READ_REF[4] READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[2] READ_ROUT0_BL_EN_5[2]
+ DI[15] DI[14] DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1] READ_DI0
+ READ_REF_MODE AVDD READ_ROUT0_BLOCK_SA_EN[2] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4] RESET_REF[3]
+ RESET_REF[2] RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1] COL_ADDR_BAR_5[0]
+ AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[2] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[2] SET_REF[6]
+ SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[2]
+ READ_SLICE_SLICE_SELECT_PRE[2] READ_SLICE_SA_EN_PRE[2] READ_SLICE_SA_CLK_PRE[2] READ_SLICE_COL_ADDR3B_PRE_5[2]
+ READ_SLICE_ARRAY_ENB_PRE_5[2] READ_SLICE_READ_REF4_BUF[2] READ_SLICE_REF_MODE_BUF[2] READ_SLICE_RESET_REF4_BUF[2]
+ READ_SLICE_SET_REF4_BUF[2] READ_SLICE_DI1_BUF[2] READ_SLICE_WEB_PRE_5[2] readout_slice
x1[1] READ_READ_MODE SLICE_SELECT_BAR_5[1] READ_ROUT0_COL_SELECT0_5[1] VDD VBL_READ SA_RDY[31]
+ SA_RDY[30] SA_RDY[29] SA_RDY[28] SA_RDY[27] SA_RDY[26] SA_RDY[25] SA_RDY[24] SA_RDY[23] SA_RDY[22] SA_RDY[21]
+ SA_RDY[20] SA_RDY[19] SA_RDY[18] SA_RDY[17] SA_RDY[16] SA_DO[31] SA_DO[30] SA_DO[29] SA_DO[28] SA_DO[27]
+ SA_DO[26] SA_DO[25] SA_DO[24] SA_DO[23] SA_DO[22] SA_DO[21] SA_DO[20] SA_DO[19] SA_DO[18] SA_DO[17] SA_DO[16]
+ SLICE_SELECT[1] BL[511] BL[510] BL[509] BL[508] BL[507] BL[506] BL[505] BL[504] BL[503] BL[502] BL[501] BL[500]
+ BL[499] BL[498] BL[497] BL[496] BL[495] BL[494] BL[493] BL[492] BL[491] BL[490] BL[489] BL[488] BL[487]
+ BL[486] BL[485] BL[484] BL[483] BL[482] BL[481] BL[480] BL[479] BL[478] BL[477] BL[476] BL[475] BL[474]
+ BL[473] BL[472] BL[471] BL[470] BL[469] BL[468] BL[467] BL[466] BL[465] BL[464] BL[463] BL[462] BL[461]
+ BL[460] BL[459] BL[458] BL[457] BL[456] BL[455] BL[454] BL[453] BL[452] BL[451] BL[450] BL[449] BL[448]
+ BL[447] BL[446] BL[445] BL[444] BL[443] BL[442] BL[441] BL[440] BL[439] BL[438] BL[437] BL[436] BL[435]
+ BL[434] BL[433] BL[432] BL[431] BL[430] BL[429] BL[428] BL[427] BL[426] BL[425] BL[424] BL[423] BL[422]
+ BL[421] BL[420] BL[419] BL[418] BL[417] BL[416] BL[415] BL[414] BL[413] BL[412] BL[411] BL[410] BL[409]
+ BL[408] BL[407] BL[406] BL[405] BL[404] BL[403] BL[402] BL[401] BL[400] BL[399] BL[398] BL[397] BL[396]
+ BL[395] BL[394] BL[393] BL[392] BL[391] BL[390] BL[389] BL[388] BL[387] BL[386] BL[385] BL[384] BL[383]
+ BL[382] BL[381] BL[380] BL[379] BL[378] BL[377] BL[376] BL[375] BL[374] BL[373] BL[372] BL[371] BL[370]
+ BL[369] BL[368] BL[367] BL[366] BL[365] BL[364] BL[363] BL[362] BL[361] BL[360] BL[359] BL[358] BL[357]
+ BL[356] BL[355] BL[354] BL[353] BL[352] BL[351] BL[350] BL[349] BL[348] BL[347] BL[346] BL[345] BL[344]
+ BL[343] BL[342] BL[341] BL[340] BL[339] BL[338] BL[337] BL[336] BL[335] BL[334] BL[333] BL[332] BL[331]
+ BL[330] BL[329] BL[328] BL[327] BL[326] BL[325] BL[324] BL[323] BL[322] BL[321] BL[320] BL[319] BL[318]
+ BL[317] BL[316] BL[315] BL[314] BL[313] BL[312] BL[311] BL[310] BL[309] BL[308] BL[307] BL[306] BL[305]
+ BL[304] BL[303] BL[302] BL[301] BL[300] BL[299] BL[298] BL[297] BL[296] BL[295] BL[294] BL[293] BL[292]
+ BL[291] BL[290] BL[289] BL[288] BL[287] BL[286] BL[285] BL[284] BL[283] BL[282] BL[281] BL[280] BL[279]
+ BL[278] BL[277] BL[276] BL[275] BL[274] BL[273] BL[272] BL[271] BL[270] BL[269] BL[268] BL[267] BL[266]
+ BL[265] BL[264] BL[263] BL[262] BL[261] BL[260] BL[259] BL[258] BL[257] BL[256] VSS READ_REF[6] READ_REF[5]
+ READ_REF[4] READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[1] READ_ROUT0_BL_EN_5[1]
+ DI[15] DI[14] DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1] READ_DI0
+ READ_REF_MODE AVDD READ_ROUT0_BLOCK_SA_EN[1] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4] RESET_REF[3]
+ RESET_REF[2] RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1] COL_ADDR_BAR_5[0]
+ AVSS READ_SA_CLK READ_ROUT15_SA_CLK_BUF[1] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[1] SET_REF[6]
+ SET_REF[5] SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[1]
+ READ_SLICE_SLICE_SELECT_PRE[1] READ_SLICE_SA_EN_PRE[1] READ_SLICE_SA_CLK_PRE[1] READ_SLICE_COL_ADDR3B_PRE_5[1]
+ READ_SLICE_ARRAY_ENB_PRE_5[1] READ_SLICE_READ_REF4_BUF[1] READ_SLICE_REF_MODE_BUF[1] READ_SLICE_RESET_REF4_BUF[1]
+ READ_SLICE_SET_REF4_BUF[1] READ_SLICE_DI1_BUF[1] READ_SLICE_WEB_PRE_5[1] readout_slice
x1[0] READ_READ_MODE SLICE_SELECT_BAR_5[0] READ_ROUT0_COL_SELECT0_5[0] VDD VBL_READ SA_RDY[15]
+ SA_RDY[14] SA_RDY[13] SA_RDY[12] SA_RDY[11] SA_RDY[10] SA_RDY[9] SA_RDY[8] SA_RDY[7] SA_RDY[6] SA_RDY[5]
+ SA_RDY[4] SA_RDY[3] SA_RDY[2] SA_RDY[1] SA_RDY[0] SA_DO[15] SA_DO[14] SA_DO[13] SA_DO[12] SA_DO[11] SA_DO[10]
+ SA_DO[9] SA_DO[8] SA_DO[7] SA_DO[6] SA_DO[5] SA_DO[4] SA_DO[3] SA_DO[2] SA_DO[1] SA_DO[0] SLICE_SELECT[0]
+ BL[255] BL[254] BL[253] BL[252] BL[251] BL[250] BL[249] BL[248] BL[247] BL[246] BL[245] BL[244] BL[243]
+ BL[242] BL[241] BL[240] BL[239] BL[238] BL[237] BL[236] BL[235] BL[234] BL[233] BL[232] BL[231] BL[230]
+ BL[229] BL[228] BL[227] BL[226] BL[225] BL[224] BL[223] BL[222] BL[221] BL[220] BL[219] BL[218] BL[217]
+ BL[216] BL[215] BL[214] BL[213] BL[212] BL[211] BL[210] BL[209] BL[208] BL[207] BL[206] BL[205] BL[204]
+ BL[203] BL[202] BL[201] BL[200] BL[199] BL[198] BL[197] BL[196] BL[195] BL[194] BL[193] BL[192] BL[191]
+ BL[190] BL[189] BL[188] BL[187] BL[186] BL[185] BL[184] BL[183] BL[182] BL[181] BL[180] BL[179] BL[178]
+ BL[177] BL[176] BL[175] BL[174] BL[173] BL[172] BL[171] BL[170] BL[169] BL[168] BL[167] BL[166] BL[165]
+ BL[164] BL[163] BL[162] BL[161] BL[160] BL[159] BL[158] BL[157] BL[156] BL[155] BL[154] BL[153] BL[152]
+ BL[151] BL[150] BL[149] BL[148] BL[147] BL[146] BL[145] BL[144] BL[143] BL[142] BL[141] BL[140] BL[139]
+ BL[138] BL[137] BL[136] BL[135] BL[134] BL[133] BL[132] BL[131] BL[130] BL[129] BL[128] BL[127] BL[126]
+ BL[125] BL[124] BL[123] BL[122] BL[121] BL[120] BL[119] BL[118] BL[117] BL[116] BL[115] BL[114] BL[113]
+ BL[112] BL[111] BL[110] BL[109] BL[108] BL[107] BL[106] BL[105] BL[104] BL[103] BL[102] BL[101] BL[100]
+ BL[99] BL[98] BL[97] BL[96] BL[95] BL[94] BL[93] BL[92] BL[91] BL[90] BL[89] BL[88] BL[87] BL[86] BL[85]
+ BL[84] BL[83] BL[82] BL[81] BL[80] BL[79] BL[78] BL[77] BL[76] BL[75] BL[74] BL[73] BL[72] BL[71] BL[70]
+ BL[69] BL[68] BL[67] BL[66] BL[65] BL[64] BL[63] BL[62] BL[61] BL[60] BL[59] BL[58] BL[57] BL[56] BL[55]
+ BL[54] BL[53] BL[52] BL[51] BL[50] BL[49] BL[48] BL[47] BL[46] BL[45] BL[44] BL[43] BL[42] BL[41] BL[40]
+ BL[39] BL[38] BL[37] BL[36] BL[35] BL[34] BL[33] BL[32] BL[31] BL[30] BL[29] BL[28] BL[27] BL[26] BL[25]
+ BL[24] BL[23] BL[22] BL[21] BL[20] BL[19] BL[18] BL[17] BL[16] BL[15] BL[14] BL[13] BL[12] BL[11] BL[10]
+ BL[9] BL[8] BL[7] BL[6] BL[5] BL[4] BL[3] BL[2] BL[1] BL[0] VSS READ_REF[6] READ_REF[5] READ_REF[4]
+ READ_REF[3] READ_REF[2] READ_REF[1] READ_REF[0] READ_ROUT0_BLOCK_SA_EN_5[0] READ_ROUT0_BL_EN_5[0] DI[15] DI[14]
+ DI[13] DI[12] DI[11] DI[10] DI[9] DI[8] DI[7] DI[6] DI[5] DI[4] DI[3] DI[2] DI[1] READ_DI0 READ_REF_MODE
+ AVDD READ_ROUT0_BLOCK_SA_EN[0] VSA WE_5 RESET_REF[6] RESET_REF[5] RESET_REF[4] RESET_REF[3] RESET_REF[2]
+ RESET_REF[1] RESET_REF[0] COL_ADDR_BAR_5[3] COL_ADDR_BAR_5[2] COL_ADDR_BAR_5[1] COL_ADDR_BAR_5[0] AVSS
+ READ_SA_CLK READ_ROUT15_SA_CLK_BUF[0] SA_EN ARRAY_EN_BAR_5 READ_ROUT15_WE_5_BUF[0] SET_REF[6] SET_REF[5]
+ SET_REF[4] SET_REF[3] SET_REF[2] SET_REF[1] SET_REF[0] READ_SLICE_SLICE_SELECTB_PRE_5[0]
+ READ_SLICE_SLICE_SELECT_PRE[0] READ_SLICE_SA_EN_PRE[0] READ_SLICE_SA_CLK_PRE[0] READ_SLICE_COL_ADDR3B_PRE_5[0]
+ READ_SLICE_ARRAY_ENB_PRE_5[0] READ_SLICE_READ_REF4_BUF[0] READ_SLICE_REF_MODE_BUF[0] READ_SLICE_RESET_REF4_BUF[0]
+ READ_SLICE_SET_REF4_BUF[0] READ_SLICE_DI1_BUF[0] READ_SLICE_WEB_PRE_5[0] readout_slice
* noconn READ_SLICE_SA_EN_PRE[8:0]
* noconn READ_SLICE_SET_REF4_BUF[8:0]
* noconn READ_SLICE_SLICE_SELECTB_PRE_5[8:0]
* noconn READ_SLICE_SLICE_SELECT_PRE[8:0]
* noconn READ_SLICE_WEB_PRE_5[8:0]
* noconn READ_ROUT15_WE_5_BUF[8:0]
* noconn READ_SLICE_ARRAY_ENB_PRE_5[8:0]
* noconn READ_SLICE_COL_ADDR3B_PRE_5[8:0]
* noconn READ_SLICE_DI1_BUF[8:0]
* noconn READ_SLICE_READ_REF4_BUF[8:0]
* noconn READ_ROUT0_BLOCK_SA_EN_5[8:0]
* noconn READ_ROUT0_BL_EN_5[8:0]
* noconn READ_ROUT0_BLOCK_SA_EN[8:0]
* noconn READ_ROUT0_COL_SELECT0_5[8:0]
* noconn READ_SLICE_REF_MODE_BUF[8:0]
* noconn READ_SLICE_RESET_REF4_BUF[8:0]
* noconn READ_ROUT15_SA_CLK_BUF[8:0]
* noconn READ_SLICE_SA_CLK_PRE[8:0]
x1 VDD COL_ADDR[7] COL_ADDR[6] COL_ADDR[5] COL_ADDR[4] SLICE_SELECT[15] SLICE_SELECT[14]
+ SLICE_SELECT[13] SLICE_SELECT[12] SLICE_SELECT[11] SLICE_SELECT[10] SLICE_SELECT[9] SLICE_SELECT[8] SLICE_SELECT[7]
+ SLICE_SELECT[6] SLICE_SELECT[5] SLICE_SELECT[4] SLICE_SELECT[3] SLICE_SELECT[2] SLICE_SELECT[1] SLICE_SELECT[0] VSS
+ decoder_4_to_16_1p8V
x2[8] AVDD SLICE_SELECT_BAR_5[8] SLICE_SELECT_5[8] VDD SLICE_SELECT_BUF[8] VSS lvl_shifter_1p8_to_5
x2[7] AVDD SLICE_SELECT_BAR_5[7] SLICE_SELECT_5[7] VDD SLICE_SELECT_BUF[7] VSS lvl_shifter_1p8_to_5
x2[6] AVDD SLICE_SELECT_BAR_5[6] SLICE_SELECT_5[6] VDD SLICE_SELECT_BUF[6] VSS lvl_shifter_1p8_to_5
x2[5] AVDD SLICE_SELECT_BAR_5[5] SLICE_SELECT_5[5] VDD SLICE_SELECT_BUF[5] VSS lvl_shifter_1p8_to_5
x2[4] AVDD SLICE_SELECT_BAR_5[4] SLICE_SELECT_5[4] VDD SLICE_SELECT_BUF[4] VSS lvl_shifter_1p8_to_5
x2[3] AVDD SLICE_SELECT_BAR_5[3] SLICE_SELECT_5[3] VDD SLICE_SELECT_BUF[3] VSS lvl_shifter_1p8_to_5
x2[2] AVDD SLICE_SELECT_BAR_5[2] SLICE_SELECT_5[2] VDD SLICE_SELECT_BUF[2] VSS lvl_shifter_1p8_to_5
x2[1] AVDD SLICE_SELECT_BAR_5[1] SLICE_SELECT_5[1] VDD SLICE_SELECT_BUF[1] VSS lvl_shifter_1p8_to_5
x2[0] AVDD SLICE_SELECT_BAR_5[0] SLICE_SELECT_5[0] VDD SLICE_SELECT_BUF[0] VSS lvl_shifter_1p8_to_5
x3 AVDD WE_BAR_5 net1 VDD WE VSS lvl_shifter_1p8_to_5
x4 AVDD net2 ARRAY_EN_5 VDD ARRAY_EN VSS lvl_shifter_1p8_to_5
x1[3] AVDD net3 COL_ADDR_5[3] VDD COL_ADDR[3] VSS lvl_shifter_1p8_to_5
x1[2] AVDD net3 COL_ADDR_5[2] VDD COL_ADDR[2] VSS lvl_shifter_1p8_to_5
x1[1] AVDD net3 COL_ADDR_5[1] VDD COL_ADDR[1] VSS lvl_shifter_1p8_to_5
x1[0] AVDD net3 COL_ADDR_5[0] VDD COL_ADDR[0] VSS lvl_shifter_1p8_to_5
x2 WE_BAR_5 VSS VSS AVDD AVDD WE_5 sky130_fd_sc_hd__inv_4
x5 ARRAY_EN_5 VSS VSS AVDD AVDD ARRAY_EN_BAR_5 sky130_fd_sc_hd__inv_4
x2[3] COL_ADDR_5[3] VSS VSS AVDD AVDD COL_ADDR_BAR_5[3] sky130_fd_sc_hd__inv_4
x2[2] COL_ADDR_5[2] VSS VSS AVDD AVDD COL_ADDR_BAR_5[2] sky130_fd_sc_hd__inv_4
x2[1] COL_ADDR_5[1] VSS VSS AVDD AVDD COL_ADDR_BAR_5[1] sky130_fd_sc_hd__inv_4
x2[0] COL_ADDR_5[0] VSS VSS AVDD AVDD COL_ADDR_BAR_5[0] sky130_fd_sc_hd__inv_4
x1[8] SLICE_SELECT[8] VSS VSS VDD VDD SLICE_SELECT_BUF[8] sky130_fd_sc_hd__buf_4
x1[7] SLICE_SELECT[7] VSS VSS VDD VDD SLICE_SELECT_BUF[7] sky130_fd_sc_hd__buf_4
x1[6] SLICE_SELECT[6] VSS VSS VDD VDD SLICE_SELECT_BUF[6] sky130_fd_sc_hd__buf_4
x1[5] SLICE_SELECT[5] VSS VSS VDD VDD SLICE_SELECT_BUF[5] sky130_fd_sc_hd__buf_4
x1[4] SLICE_SELECT[4] VSS VSS VDD VDD SLICE_SELECT_BUF[4] sky130_fd_sc_hd__buf_4
x1[3] SLICE_SELECT[3] VSS VSS VDD VDD SLICE_SELECT_BUF[3] sky130_fd_sc_hd__buf_2
x1[2] SLICE_SELECT[2] VSS VSS VDD VDD SLICE_SELECT_BUF[2] sky130_fd_sc_hd__buf_2
* noconn SLICE_SELECT[15:9]
R2[0] SLICE_SELECT[1] SLICE_SELECT_BUF[1] 0 m=1
R2[1] SLICE_SELECT[0] SLICE_SELECT_BUF[0] 0 m=1
* noconn SLICE_SELECT_5[8:0]
* noconn #net1
* noconn #net2
* noconn #net3
R1[0] DI[0] READ_DI0 0 m=1
R1[1] DI[0] READ_DI0 0 m=1
R3[0] SET_REF[1] READ_SET_REF[1] 0 m=1
R3[1] SET_REF[1] READ_SET_REF[1] 0 m=1
R4[0] RESET_REF[0] READ_RESET_REF[0] 0 m=1
R4[1] RESET_REF[0] READ_RESET_REF[0] 0 m=1
R5[0] READ_REF[0] READ_READ_REF[0] 0 m=1
R5[1] READ_REF[0] READ_READ_REF[0] 0 m=1
R6[0] READ_MODE READ_READ_MODE 0 m=1
R6[1] READ_MODE READ_READ_MODE 0 m=1
R7[0] SA_CLK READ_SA_CLK 0 m=1
R7[1] SA_CLK READ_SA_CLK 0 m=1
R8[0] REF_MODE READ_REF_MODE 0 m=1
R8[1] REF_MODE READ_REF_MODE 0 m=1
**.ends
.end
